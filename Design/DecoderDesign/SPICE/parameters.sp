simulator lang=spectre

parameters PWmin = 100n                         //MinimalTransistorWidth
parameters PLmin = 45n                          //MinimalTransistorLenght

parameters numberofruns = 1
parameters enableMismatch = 0
parameters simlength = 3.84e-07

parameters wavein_0=[0 0 1e-09 0 1.05e-09 0 2e-09 0 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 8e-09 0 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.01e-08 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.4e-08 0 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.61e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2e-08 0 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.21e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.6e-08 0 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.81e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.2e-08 0 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.41e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 3.8e-08 0 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.01e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.4e-08 0 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.61e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5e-08 0 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.21e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.60000000000001e-08 0 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.81000000000001e-08 1 5.90000000000001e-08 1 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.10500000000001e-08 0 6.20000000000001e-08 0 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.41e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 6.8e-08 0 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.01e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.4e-08 0 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.61e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8e-08 0 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.21e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.59999999999999e-08 0 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80999999999999e-08 1 8.89999999999999e-08 1 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10499999999999e-08 0 9.19999999999999e-08 0 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40999999999999e-08 1 9.49999999999999e-08 1 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70499999999999e-08 0 9.79999999999999e-08 0 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.001e-07 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.04e-07 0 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.061e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.1e-07 0 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.121e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.16e-07 0 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.181e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.22e-07 0 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.241e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.28e-07 0 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.301e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.34e-07 0 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.361e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.4e-07 0 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.421e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.46e-07 0 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.481e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.52e-07 0 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.541e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.58e-07 0 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.601e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.64e-07 0 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.661e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.7e-07 0 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.721e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.76e-07 0 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.781e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.82e-07 0 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.841e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.88e-07 0 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.901e-07 1 1.91e-07 1 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93049999999999e-07 0 1.93999999999999e-07 0 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96099999999999e-07 1 1.96999999999999e-07 1 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99049999999999e-07 0 1.99999999999999e-07 0 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02099999999999e-07 1 2.02999999999999e-07 1 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05049999999999e-07 0 2.05999999999999e-07 0 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08099999999999e-07 1 2.08999999999999e-07 1 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11049999999999e-07 0 2.11999999999999e-07 0 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14099999999999e-07 1 2.14999999999999e-07 1 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17049999999999e-07 0 2.17999999999999e-07 0 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20099999999999e-07 1 2.20999999999999e-07 1 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23049999999999e-07 0 2.23999999999999e-07 0 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26099999999999e-07 1 2.26999999999999e-07 1 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29049999999999e-07 0 2.29999999999999e-07 0 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32099999999999e-07 1 2.32999999999999e-07 1 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35049999999999e-07 0 2.35999999999999e-07 0 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38099999999999e-07 1 2.38999999999999e-07 1 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41049999999999e-07 0 2.41999999999999e-07 0 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44099999999999e-07 1 2.44999999999999e-07 1 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.4705e-07 0 2.48e-07 0 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.501e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.54e-07 0 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.561e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.6e-07 0 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.621e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.66e-07 0 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.681e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.72e-07 0 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.741e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.78e-07 0 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.801e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.84e-07 0 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.861e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.9e-07 0 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92100000000001e-07 1 2.93000000000001e-07 1 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95050000000001e-07 0 2.96000000000001e-07 0 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98100000000001e-07 1 2.99000000000001e-07 1 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01050000000001e-07 0 3.02000000000001e-07 0 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04100000000001e-07 1 3.05000000000001e-07 1 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07050000000001e-07 0 3.08000000000001e-07 0 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10100000000001e-07 1 3.11000000000001e-07 1 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13050000000001e-07 0 3.14000000000001e-07 0 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16100000000001e-07 1 3.17000000000001e-07 1 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19050000000001e-07 0 3.20000000000001e-07 0 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22100000000001e-07 1 3.23000000000001e-07 1 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25050000000001e-07 0 3.26000000000001e-07 0 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28100000000001e-07 1 3.29000000000001e-07 1 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31050000000001e-07 0 3.32000000000001e-07 0 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34100000000001e-07 1 3.35000000000001e-07 1 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37050000000001e-07 0 3.38000000000002e-07 0 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40100000000002e-07 1 3.41000000000002e-07 1 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43050000000002e-07 0 3.44000000000002e-07 0 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46100000000002e-07 1 3.47000000000002e-07 1 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49050000000002e-07 0 3.50000000000002e-07 0 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52100000000002e-07 1 3.53000000000002e-07 1 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55050000000002e-07 0 3.56000000000002e-07 0 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58100000000002e-07 1 3.59000000000002e-07 1 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61050000000002e-07 0 3.62000000000002e-07 0 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64100000000002e-07 1 3.65000000000002e-07 1 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67050000000002e-07 0 3.68000000000002e-07 0 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70100000000002e-07 1 3.71000000000002e-07 1 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73050000000002e-07 0 3.74000000000002e-07 0 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76100000000002e-07 1 3.77000000000002e-07 1 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79050000000002e-07 0 3.80000000000002e-07 0 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
parameters wavein_1=[0 0 1e-09 0 1.05e-09 0 2e-09 0 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 8e-09 1 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.01e-08 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.4e-08 0 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.605e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2e-08 1 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.21e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.6e-08 0 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.805e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.2e-08 1 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.41e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 3.8e-08 0 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.005e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.4e-08 1 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.61e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5e-08 0 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.205e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51000000000001e-08 1 5.60000000000001e-08 1 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.81000000000001e-08 1 5.90000000000001e-08 1 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.10500000000001e-08 0 6.20000000000001e-08 0 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.405e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 6.8e-08 1 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.01e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.4e-08 0 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.605e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8e-08 1 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.21e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.59999999999999e-08 0 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80499999999999e-08 0 8.89999999999999e-08 0 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10999999999999e-08 1 9.19999999999999e-08 1 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40999999999999e-08 1 9.49999999999999e-08 1 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70499999999999e-08 0 9.79999999999999e-08 0 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.0005e-07 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.04e-07 1 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.061e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.1e-07 0 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.1205e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.16e-07 1 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.181e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.22e-07 0 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.2405e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.28e-07 1 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.301e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.34e-07 0 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.3605e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.4e-07 1 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.421e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.46e-07 0 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.4805e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.52e-07 1 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.541e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.58e-07 0 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.6005e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.64e-07 1 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.661e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.7e-07 0 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.7205e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.76e-07 1 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.781e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.82e-07 0 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.8405e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.88e-07 1 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.901e-07 1 1.91e-07 1 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93049999999999e-07 0 1.93999999999999e-07 0 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96049999999999e-07 0 1.96999999999999e-07 0 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99099999999999e-07 1 1.99999999999999e-07 1 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02099999999999e-07 1 2.02999999999999e-07 1 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05049999999999e-07 0 2.05999999999999e-07 0 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08049999999999e-07 0 2.08999999999999e-07 0 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11099999999999e-07 1 2.11999999999999e-07 1 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14099999999999e-07 1 2.14999999999999e-07 1 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17049999999999e-07 0 2.17999999999999e-07 0 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20049999999999e-07 0 2.20999999999999e-07 0 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23099999999999e-07 1 2.23999999999999e-07 1 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26099999999999e-07 1 2.26999999999999e-07 1 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29049999999999e-07 0 2.29999999999999e-07 0 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32049999999999e-07 0 2.32999999999999e-07 0 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35099999999999e-07 1 2.35999999999999e-07 1 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38099999999999e-07 1 2.38999999999999e-07 1 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41049999999999e-07 0 2.41999999999999e-07 0 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44049999999999e-07 0 2.44999999999999e-07 0 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.471e-07 1 2.48e-07 1 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.501e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.54e-07 0 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.5605e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.6e-07 1 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.621e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.66e-07 0 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.6805e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.72e-07 1 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.741e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.78e-07 0 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.8005e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.84e-07 1 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.861e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.9e-07 0 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92050000000001e-07 0 2.93000000000001e-07 0 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95100000000001e-07 1 2.96000000000001e-07 1 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98100000000001e-07 1 2.99000000000001e-07 1 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01050000000001e-07 0 3.02000000000001e-07 0 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04050000000001e-07 0 3.05000000000001e-07 0 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07100000000001e-07 1 3.08000000000001e-07 1 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10100000000001e-07 1 3.11000000000001e-07 1 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13050000000001e-07 0 3.14000000000001e-07 0 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16050000000001e-07 0 3.17000000000001e-07 0 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19100000000001e-07 1 3.20000000000001e-07 1 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22100000000001e-07 1 3.23000000000001e-07 1 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25050000000001e-07 0 3.26000000000001e-07 0 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28050000000001e-07 0 3.29000000000001e-07 0 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31100000000001e-07 1 3.32000000000001e-07 1 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34100000000001e-07 1 3.35000000000001e-07 1 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37050000000001e-07 0 3.38000000000002e-07 0 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40050000000002e-07 0 3.41000000000002e-07 0 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43100000000002e-07 1 3.44000000000002e-07 1 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46100000000002e-07 1 3.47000000000002e-07 1 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49050000000002e-07 0 3.50000000000002e-07 0 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52050000000002e-07 0 3.53000000000002e-07 0 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55100000000002e-07 1 3.56000000000002e-07 1 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58100000000002e-07 1 3.59000000000002e-07 1 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61050000000002e-07 0 3.62000000000002e-07 0 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64050000000002e-07 0 3.65000000000002e-07 0 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67100000000002e-07 1 3.68000000000002e-07 1 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70100000000002e-07 1 3.71000000000002e-07 1 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73050000000002e-07 0 3.74000000000002e-07 0 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76050000000002e-07 0 3.77000000000002e-07 0 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79100000000002e-07 1 3.80000000000002e-07 1 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
parameters wavein_2=[0 0 1e-09 0 1.05e-09 0 2e-09 0 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 8e-09 0 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.005e-08 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.4e-08 1 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.61e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2e-08 1 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.21e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.6e-08 0 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.805e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.2e-08 0 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.405e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 3.8e-08 1 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.01e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.4e-08 1 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.61e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5e-08 0 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.205e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.60000000000001e-08 0 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.80500000000001e-08 0 5.90000000000001e-08 0 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.11000000000001e-08 1 6.20000000000001e-08 1 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.41e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 6.8e-08 1 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.01e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.4e-08 0 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.605e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8e-08 0 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.205e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.50999999999999e-08 1 8.59999999999999e-08 1 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80999999999999e-08 1 8.89999999999999e-08 1 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10999999999999e-08 1 9.19999999999999e-08 1 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40999999999999e-08 1 9.49999999999999e-08 1 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70499999999999e-08 0 9.79999999999999e-08 0 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.0005e-07 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.04e-07 0 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.0605e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.1e-07 1 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.121e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.16e-07 1 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.181e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.22e-07 0 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.2405e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.28e-07 0 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.3005e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.34e-07 1 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.361e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.4e-07 1 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.421e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.46e-07 0 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.4805e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.52e-07 0 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.5405e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.58e-07 1 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.601e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.64e-07 1 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.661e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.7e-07 0 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.7205e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.76e-07 0 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.7805e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.82e-07 1 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.841e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.88e-07 1 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.901e-07 1 1.91e-07 1 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93049999999999e-07 0 1.93999999999999e-07 0 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96049999999999e-07 0 1.96999999999999e-07 0 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99049999999999e-07 0 1.99999999999999e-07 0 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02049999999999e-07 0 2.02999999999999e-07 0 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05099999999999e-07 1 2.05999999999999e-07 1 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08099999999999e-07 1 2.08999999999999e-07 1 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11099999999999e-07 1 2.11999999999999e-07 1 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14099999999999e-07 1 2.14999999999999e-07 1 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17049999999999e-07 0 2.17999999999999e-07 0 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20049999999999e-07 0 2.20999999999999e-07 0 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23049999999999e-07 0 2.23999999999999e-07 0 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26049999999999e-07 0 2.26999999999999e-07 0 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29099999999999e-07 1 2.29999999999999e-07 1 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32099999999999e-07 1 2.32999999999999e-07 1 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35099999999999e-07 1 2.35999999999999e-07 1 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38099999999999e-07 1 2.38999999999999e-07 1 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41049999999999e-07 0 2.41999999999999e-07 0 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44049999999999e-07 0 2.44999999999999e-07 0 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.4705e-07 0 2.48e-07 0 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.5005e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.54e-07 1 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.561e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.6e-07 1 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.621e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.66e-07 0 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.6805e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.72e-07 0 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.7405e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.78e-07 1 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.801e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.84e-07 1 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.861e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.9e-07 0 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92050000000001e-07 0 2.93000000000001e-07 0 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95050000000001e-07 0 2.96000000000001e-07 0 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98050000000001e-07 0 2.99000000000001e-07 0 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01100000000001e-07 1 3.02000000000001e-07 1 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04100000000001e-07 1 3.05000000000001e-07 1 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07100000000001e-07 1 3.08000000000001e-07 1 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10100000000001e-07 1 3.11000000000001e-07 1 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13050000000001e-07 0 3.14000000000001e-07 0 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16050000000001e-07 0 3.17000000000001e-07 0 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19050000000001e-07 0 3.20000000000001e-07 0 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22050000000001e-07 0 3.23000000000001e-07 0 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25100000000001e-07 1 3.26000000000001e-07 1 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28100000000001e-07 1 3.29000000000001e-07 1 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31100000000001e-07 1 3.32000000000001e-07 1 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34100000000001e-07 1 3.35000000000001e-07 1 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37050000000001e-07 0 3.38000000000002e-07 0 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40050000000002e-07 0 3.41000000000002e-07 0 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43050000000002e-07 0 3.44000000000002e-07 0 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46050000000002e-07 0 3.47000000000002e-07 0 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49100000000002e-07 1 3.50000000000002e-07 1 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52100000000002e-07 1 3.53000000000002e-07 1 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55100000000002e-07 1 3.56000000000002e-07 1 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58100000000002e-07 1 3.59000000000002e-07 1 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61050000000002e-07 0 3.62000000000002e-07 0 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64050000000002e-07 0 3.65000000000002e-07 0 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67050000000002e-07 0 3.68000000000002e-07 0 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70050000000002e-07 0 3.71000000000002e-07 0 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73100000000002e-07 1 3.74000000000002e-07 1 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76100000000002e-07 1 3.77000000000002e-07 1 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79100000000002e-07 1 3.80000000000002e-07 1 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
parameters wavein_3=[0 0 1e-09 0 1.05e-09 0 2e-09 0 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 8e-09 0 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.005e-08 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.4e-08 0 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.605e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2e-08 0 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.205e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.6e-08 1 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.81e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.2e-08 1 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.41e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 3.8e-08 1 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.01e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.4e-08 1 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.61e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5e-08 0 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.205e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.60000000000001e-08 0 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.80500000000001e-08 0 5.90000000000001e-08 0 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.10500000000001e-08 0 6.20000000000001e-08 0 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.405e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 6.8e-08 0 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.005e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.4e-08 1 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.61e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8e-08 1 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.21e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.50999999999999e-08 1 8.59999999999999e-08 1 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80999999999999e-08 1 8.89999999999999e-08 1 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10999999999999e-08 1 9.19999999999999e-08 1 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40999999999999e-08 1 9.49999999999999e-08 1 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70499999999999e-08 0 9.79999999999999e-08 0 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.0005e-07 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.04e-07 0 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.0605e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.1e-07 0 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.1205e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.16e-07 0 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.1805e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.22e-07 1 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.241e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.28e-07 1 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.301e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.34e-07 1 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.361e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.4e-07 1 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.421e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.46e-07 0 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.4805e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.52e-07 0 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.5405e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.58e-07 0 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.6005e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.64e-07 0 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.6605e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.7e-07 1 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.721e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.76e-07 1 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.781e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.82e-07 1 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.841e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.88e-07 1 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.901e-07 1 1.91e-07 1 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93049999999999e-07 0 1.93999999999999e-07 0 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96049999999999e-07 0 1.96999999999999e-07 0 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99049999999999e-07 0 1.99999999999999e-07 0 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02049999999999e-07 0 2.02999999999999e-07 0 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05049999999999e-07 0 2.05999999999999e-07 0 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08049999999999e-07 0 2.08999999999999e-07 0 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11049999999999e-07 0 2.11999999999999e-07 0 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14049999999999e-07 0 2.14999999999999e-07 0 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17099999999999e-07 1 2.17999999999999e-07 1 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20099999999999e-07 1 2.20999999999999e-07 1 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23099999999999e-07 1 2.23999999999999e-07 1 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26099999999999e-07 1 2.26999999999999e-07 1 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29099999999999e-07 1 2.29999999999999e-07 1 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32099999999999e-07 1 2.32999999999999e-07 1 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35099999999999e-07 1 2.35999999999999e-07 1 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38099999999999e-07 1 2.38999999999999e-07 1 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41049999999999e-07 0 2.41999999999999e-07 0 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44049999999999e-07 0 2.44999999999999e-07 0 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.4705e-07 0 2.48e-07 0 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.5005e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.54e-07 0 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.5605e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.6e-07 0 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.6205e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.66e-07 1 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.681e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.72e-07 1 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.741e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.78e-07 1 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.801e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.84e-07 1 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.861e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.9e-07 0 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92050000000001e-07 0 2.93000000000001e-07 0 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95050000000001e-07 0 2.96000000000001e-07 0 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98050000000001e-07 0 2.99000000000001e-07 0 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01050000000001e-07 0 3.02000000000001e-07 0 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04050000000001e-07 0 3.05000000000001e-07 0 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07050000000001e-07 0 3.08000000000001e-07 0 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10050000000001e-07 0 3.11000000000001e-07 0 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13100000000001e-07 1 3.14000000000001e-07 1 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16100000000001e-07 1 3.17000000000001e-07 1 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19100000000001e-07 1 3.20000000000001e-07 1 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22100000000001e-07 1 3.23000000000001e-07 1 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25100000000001e-07 1 3.26000000000001e-07 1 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28100000000001e-07 1 3.29000000000001e-07 1 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31100000000001e-07 1 3.32000000000001e-07 1 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34100000000001e-07 1 3.35000000000001e-07 1 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37050000000001e-07 0 3.38000000000002e-07 0 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40050000000002e-07 0 3.41000000000002e-07 0 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43050000000002e-07 0 3.44000000000002e-07 0 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46050000000002e-07 0 3.47000000000002e-07 0 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49050000000002e-07 0 3.50000000000002e-07 0 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52050000000002e-07 0 3.53000000000002e-07 0 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55050000000002e-07 0 3.56000000000002e-07 0 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58050000000002e-07 0 3.59000000000002e-07 0 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61100000000002e-07 1 3.62000000000002e-07 1 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64100000000002e-07 1 3.65000000000002e-07 1 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67100000000002e-07 1 3.68000000000002e-07 1 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70100000000002e-07 1 3.71000000000002e-07 1 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73100000000002e-07 1 3.74000000000002e-07 1 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76100000000002e-07 1 3.77000000000002e-07 1 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79100000000002e-07 1 3.80000000000002e-07 1 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
parameters wavein_4=[0 0 1e-09 0 1.05e-09 0 2e-09 0 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 8e-09 0 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.005e-08 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.4e-08 0 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.605e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2e-08 0 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.205e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.6e-08 0 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.805e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.2e-08 0 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.405e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 3.8e-08 0 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.005e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.4e-08 0 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.605e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5e-08 1 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.21e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51000000000001e-08 1 5.60000000000001e-08 1 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.81000000000001e-08 1 5.90000000000001e-08 1 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.11000000000001e-08 1 6.20000000000001e-08 1 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.41e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 6.8e-08 1 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.01e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.4e-08 1 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.61e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8e-08 1 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.21e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.50999999999999e-08 1 8.59999999999999e-08 1 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80999999999999e-08 1 8.89999999999999e-08 1 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10999999999999e-08 1 9.19999999999999e-08 1 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40999999999999e-08 1 9.49999999999999e-08 1 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70499999999999e-08 0 9.79999999999999e-08 0 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.0005e-07 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.04e-07 0 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.0605e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.1e-07 0 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.1205e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.16e-07 0 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.1805e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.22e-07 0 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.2405e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.28e-07 0 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.3005e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.34e-07 0 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.3605e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.4e-07 0 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.4205e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.46e-07 1 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.481e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.52e-07 1 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.541e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.58e-07 1 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.601e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.64e-07 1 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.661e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.7e-07 1 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.721e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.76e-07 1 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.781e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.82e-07 1 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.841e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.88e-07 1 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.901e-07 1 1.91e-07 1 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93049999999999e-07 0 1.93999999999999e-07 0 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96049999999999e-07 0 1.96999999999999e-07 0 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99049999999999e-07 0 1.99999999999999e-07 0 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02049999999999e-07 0 2.02999999999999e-07 0 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05049999999999e-07 0 2.05999999999999e-07 0 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08049999999999e-07 0 2.08999999999999e-07 0 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11049999999999e-07 0 2.11999999999999e-07 0 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14049999999999e-07 0 2.14999999999999e-07 0 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17049999999999e-07 0 2.17999999999999e-07 0 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20049999999999e-07 0 2.20999999999999e-07 0 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23049999999999e-07 0 2.23999999999999e-07 0 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26049999999999e-07 0 2.26999999999999e-07 0 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29049999999999e-07 0 2.29999999999999e-07 0 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32049999999999e-07 0 2.32999999999999e-07 0 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35049999999999e-07 0 2.35999999999999e-07 0 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38049999999999e-07 0 2.38999999999999e-07 0 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41099999999999e-07 1 2.41999999999999e-07 1 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44099999999999e-07 1 2.44999999999999e-07 1 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.471e-07 1 2.48e-07 1 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.501e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.54e-07 1 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.561e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.6e-07 1 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.621e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.66e-07 1 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.681e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.72e-07 1 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.741e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.78e-07 1 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.801e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.84e-07 1 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.861e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.9e-07 0 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92050000000001e-07 0 2.93000000000001e-07 0 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95050000000001e-07 0 2.96000000000001e-07 0 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98050000000001e-07 0 2.99000000000001e-07 0 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01050000000001e-07 0 3.02000000000001e-07 0 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04050000000001e-07 0 3.05000000000001e-07 0 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07050000000001e-07 0 3.08000000000001e-07 0 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10050000000001e-07 0 3.11000000000001e-07 0 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13050000000001e-07 0 3.14000000000001e-07 0 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16050000000001e-07 0 3.17000000000001e-07 0 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19050000000001e-07 0 3.20000000000001e-07 0 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22050000000001e-07 0 3.23000000000001e-07 0 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25050000000001e-07 0 3.26000000000001e-07 0 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28050000000001e-07 0 3.29000000000001e-07 0 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31050000000001e-07 0 3.32000000000001e-07 0 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34050000000001e-07 0 3.35000000000001e-07 0 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37100000000002e-07 1 3.38000000000002e-07 1 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40100000000002e-07 1 3.41000000000002e-07 1 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43100000000002e-07 1 3.44000000000002e-07 1 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46100000000002e-07 1 3.47000000000002e-07 1 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49100000000002e-07 1 3.50000000000002e-07 1 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52100000000002e-07 1 3.53000000000002e-07 1 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55100000000002e-07 1 3.56000000000002e-07 1 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58100000000002e-07 1 3.59000000000002e-07 1 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61100000000002e-07 1 3.62000000000002e-07 1 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64100000000002e-07 1 3.65000000000002e-07 1 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67100000000002e-07 1 3.68000000000002e-07 1 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70100000000002e-07 1 3.71000000000002e-07 1 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73100000000002e-07 1 3.74000000000002e-07 1 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76100000000002e-07 1 3.77000000000002e-07 1 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79100000000002e-07 1 3.80000000000002e-07 1 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
parameters wavein_5=[0 0 1e-09 0 1.05e-09 0 2e-09 0 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 8e-09 0 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.005e-08 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.4e-08 0 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.605e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2e-08 0 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.205e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.6e-08 0 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.805e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.2e-08 0 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.405e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 3.8e-08 0 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.005e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.4e-08 0 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.605e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5e-08 0 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.205e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.60000000000001e-08 0 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.80500000000001e-08 0 5.90000000000001e-08 0 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.10500000000001e-08 0 6.20000000000001e-08 0 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.405e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 6.8e-08 0 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.005e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.4e-08 0 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.605e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8e-08 0 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.205e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.59999999999999e-08 0 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80499999999999e-08 0 8.89999999999999e-08 0 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10499999999999e-08 0 9.19999999999999e-08 0 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40499999999999e-08 0 9.49999999999999e-08 0 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70999999999999e-08 1 9.79999999999999e-08 1 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.001e-07 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.04e-07 1 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.061e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.1e-07 1 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.121e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.16e-07 1 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.181e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.22e-07 1 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.241e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.28e-07 1 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.301e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.34e-07 1 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.361e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.4e-07 1 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.421e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.46e-07 1 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.481e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.52e-07 1 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.541e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.58e-07 1 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.601e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.64e-07 1 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.661e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.7e-07 1 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.721e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.76e-07 1 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.781e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.82e-07 1 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.841e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.88e-07 1 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.901e-07 1 1.91e-07 1 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93049999999999e-07 0 1.93999999999999e-07 0 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96049999999999e-07 0 1.96999999999999e-07 0 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99049999999999e-07 0 1.99999999999999e-07 0 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02049999999999e-07 0 2.02999999999999e-07 0 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05049999999999e-07 0 2.05999999999999e-07 0 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08049999999999e-07 0 2.08999999999999e-07 0 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11049999999999e-07 0 2.11999999999999e-07 0 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14049999999999e-07 0 2.14999999999999e-07 0 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17049999999999e-07 0 2.17999999999999e-07 0 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20049999999999e-07 0 2.20999999999999e-07 0 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23049999999999e-07 0 2.23999999999999e-07 0 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26049999999999e-07 0 2.26999999999999e-07 0 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29049999999999e-07 0 2.29999999999999e-07 0 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32049999999999e-07 0 2.32999999999999e-07 0 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35049999999999e-07 0 2.35999999999999e-07 0 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38049999999999e-07 0 2.38999999999999e-07 0 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41049999999999e-07 0 2.41999999999999e-07 0 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44049999999999e-07 0 2.44999999999999e-07 0 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.4705e-07 0 2.48e-07 0 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.5005e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.54e-07 0 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.5605e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.6e-07 0 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.6205e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.66e-07 0 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.6805e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.72e-07 0 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.7405e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.78e-07 0 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.8005e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.84e-07 0 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.8605e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.9e-07 1 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92100000000001e-07 1 2.93000000000001e-07 1 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95100000000001e-07 1 2.96000000000001e-07 1 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98100000000001e-07 1 2.99000000000001e-07 1 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01100000000001e-07 1 3.02000000000001e-07 1 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04100000000001e-07 1 3.05000000000001e-07 1 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07100000000001e-07 1 3.08000000000001e-07 1 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10100000000001e-07 1 3.11000000000001e-07 1 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13100000000001e-07 1 3.14000000000001e-07 1 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16100000000001e-07 1 3.17000000000001e-07 1 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19100000000001e-07 1 3.20000000000001e-07 1 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22100000000001e-07 1 3.23000000000001e-07 1 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25100000000001e-07 1 3.26000000000001e-07 1 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28100000000001e-07 1 3.29000000000001e-07 1 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31100000000001e-07 1 3.32000000000001e-07 1 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34100000000001e-07 1 3.35000000000001e-07 1 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37100000000002e-07 1 3.38000000000002e-07 1 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40100000000002e-07 1 3.41000000000002e-07 1 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43100000000002e-07 1 3.44000000000002e-07 1 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46100000000002e-07 1 3.47000000000002e-07 1 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49100000000002e-07 1 3.50000000000002e-07 1 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52100000000002e-07 1 3.53000000000002e-07 1 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55100000000002e-07 1 3.56000000000002e-07 1 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58100000000002e-07 1 3.59000000000002e-07 1 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61100000000002e-07 1 3.62000000000002e-07 1 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64100000000002e-07 1 3.65000000000002e-07 1 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67100000000002e-07 1 3.68000000000002e-07 1 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70100000000002e-07 1 3.71000000000002e-07 1 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73100000000002e-07 1 3.74000000000002e-07 1 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76100000000002e-07 1 3.77000000000002e-07 1 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79100000000002e-07 1 3.80000000000002e-07 1 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
parameters wavein_6=[0 0 1e-09 0 1.05e-09 0 2e-09 0 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 8e-09 0 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.005e-08 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.4e-08 0 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.605e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2e-08 0 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.205e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.6e-08 0 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.805e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.2e-08 0 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.405e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 3.8e-08 0 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.005e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.4e-08 0 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.605e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5e-08 0 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.205e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.60000000000001e-08 0 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.80500000000001e-08 0 5.90000000000001e-08 0 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.10500000000001e-08 0 6.20000000000001e-08 0 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.405e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 6.8e-08 0 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.005e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.4e-08 0 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.605e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8e-08 0 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.205e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.59999999999999e-08 0 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80499999999999e-08 0 8.89999999999999e-08 0 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10499999999999e-08 0 9.19999999999999e-08 0 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40499999999999e-08 0 9.49999999999999e-08 0 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70499999999999e-08 0 9.79999999999999e-08 0 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.0005e-07 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.04e-07 0 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.0605e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.1e-07 0 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.1205e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.16e-07 0 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.1805e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.22e-07 0 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.2405e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.28e-07 0 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.3005e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.34e-07 0 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.3605e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.4e-07 0 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.4205e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.46e-07 0 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.4805e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.52e-07 0 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.5405e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.58e-07 0 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.6005e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.64e-07 0 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.6605e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.7e-07 0 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.7205e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.76e-07 0 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.7805e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.82e-07 0 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.8405e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.88e-07 0 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.9005e-07 0 1.91e-07 0 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93099999999999e-07 1 1.93999999999999e-07 1 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96099999999999e-07 1 1.96999999999999e-07 1 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99099999999999e-07 1 1.99999999999999e-07 1 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02099999999999e-07 1 2.02999999999999e-07 1 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05099999999999e-07 1 2.05999999999999e-07 1 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08099999999999e-07 1 2.08999999999999e-07 1 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11099999999999e-07 1 2.11999999999999e-07 1 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14099999999999e-07 1 2.14999999999999e-07 1 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17099999999999e-07 1 2.17999999999999e-07 1 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20099999999999e-07 1 2.20999999999999e-07 1 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23099999999999e-07 1 2.23999999999999e-07 1 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26099999999999e-07 1 2.26999999999999e-07 1 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29099999999999e-07 1 2.29999999999999e-07 1 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32099999999999e-07 1 2.32999999999999e-07 1 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35099999999999e-07 1 2.35999999999999e-07 1 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38099999999999e-07 1 2.38999999999999e-07 1 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41099999999999e-07 1 2.41999999999999e-07 1 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44099999999999e-07 1 2.44999999999999e-07 1 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.471e-07 1 2.48e-07 1 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.501e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.54e-07 1 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.561e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.6e-07 1 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.621e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.66e-07 1 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.681e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.72e-07 1 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.741e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.78e-07 1 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.801e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.84e-07 1 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.861e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.9e-07 1 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92100000000001e-07 1 2.93000000000001e-07 1 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95100000000001e-07 1 2.96000000000001e-07 1 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98100000000001e-07 1 2.99000000000001e-07 1 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01100000000001e-07 1 3.02000000000001e-07 1 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04100000000001e-07 1 3.05000000000001e-07 1 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07100000000001e-07 1 3.08000000000001e-07 1 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10100000000001e-07 1 3.11000000000001e-07 1 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13100000000001e-07 1 3.14000000000001e-07 1 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16100000000001e-07 1 3.17000000000001e-07 1 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19100000000001e-07 1 3.20000000000001e-07 1 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22100000000001e-07 1 3.23000000000001e-07 1 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25100000000001e-07 1 3.26000000000001e-07 1 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28100000000001e-07 1 3.29000000000001e-07 1 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31100000000001e-07 1 3.32000000000001e-07 1 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34100000000001e-07 1 3.35000000000001e-07 1 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37100000000002e-07 1 3.38000000000002e-07 1 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40100000000002e-07 1 3.41000000000002e-07 1 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43100000000002e-07 1 3.44000000000002e-07 1 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46100000000002e-07 1 3.47000000000002e-07 1 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49100000000002e-07 1 3.50000000000002e-07 1 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52100000000002e-07 1 3.53000000000002e-07 1 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55100000000002e-07 1 3.56000000000002e-07 1 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58100000000002e-07 1 3.59000000000002e-07 1 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61100000000002e-07 1 3.62000000000002e-07 1 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64100000000002e-07 1 3.65000000000002e-07 1 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67100000000002e-07 1 3.68000000000002e-07 1 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70100000000002e-07 1 3.71000000000002e-07 1 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73100000000002e-07 1 3.74000000000002e-07 1 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76100000000002e-07 1 3.77000000000002e-07 1 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79100000000002e-07 1 3.80000000000002e-07 1 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
parameters waveen = [0 0 1e-09 0 1.1e-09 1 2e-09 1 2.05e-09 0 3e-09 0 3.05e-09 0 4e-09 0 4.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 8e-09 1 8.05e-09 0 9e-09 0 9.05e-09 0 1e-08 0 1.01e-08 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.4e-08 1 1.405e-08 0 1.5e-08 0 1.505e-08 0 1.6e-08 0 1.61e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2e-08 1 2.005e-08 0 2.1e-08 0 2.105e-08 0 2.2e-08 0 2.21e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.6e-08 1 2.605e-08 0 2.7e-08 0 2.705e-08 0 2.8e-08 0 2.81e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.2e-08 1 3.205e-08 0 3.3e-08 0 3.305e-08 0 3.4e-08 0 3.41e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 3.8e-08 1 3.805e-08 0 3.9e-08 0 3.905e-08 0 4e-08 0 4.01e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.4e-08 1 4.405e-08 0 4.5e-08 0 4.505e-08 0 4.6e-08 0 4.61e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5e-08 1 5.005e-08 0 5.1e-08 0 5.105e-08 0 5.2e-08 0 5.21e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51000000000001e-08 1 5.60000000000001e-08 1 5.605e-08 0 5.70000000000001e-08 0 5.70500000000001e-08 0 5.80000000000001e-08 0 5.81000000000001e-08 1 5.90000000000001e-08 1 5.90500000000001e-08 0 6.00000000000001e-08 0 6.00500000000001e-08 0 6.10000000000001e-08 0 6.11000000000001e-08 1 6.20000000000001e-08 1 6.20500000000001e-08 0 6.3e-08 0 6.30500000000001e-08 0 6.4e-08 0 6.41e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 6.8e-08 1 6.805e-08 0 6.9e-08 0 6.905e-08 0 7e-08 0 7.01e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.4e-08 1 7.405e-08 0 7.5e-08 0 7.505e-08 0 7.6e-08 0 7.61e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8e-08 1 8.005e-08 0 8.1e-08 0 8.105e-08 0 8.2e-08 0 8.21e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.50999999999999e-08 1 8.59999999999999e-08 1 8.605e-08 0 8.69999999999999e-08 0 8.70499999999999e-08 0 8.79999999999999e-08 0 8.80999999999999e-08 1 8.89999999999999e-08 1 8.90499999999999e-08 0 8.99999999999999e-08 0 9.00499999999999e-08 0 9.09999999999999e-08 0 9.10999999999999e-08 1 9.19999999999999e-08 1 9.20499999999999e-08 0 9.29999999999999e-08 0 9.30499999999999e-08 0 9.39999999999999e-08 0 9.40999999999999e-08 1 9.49999999999999e-08 1 9.50499999999999e-08 0 9.59999999999999e-08 0 9.60499999999999e-08 0 9.69999999999999e-08 0 9.70999999999999e-08 1 9.79999999999999e-08 1 9.80499999999999e-08 0 9.89999999999999e-08 0 9.90499999999999e-08 0 9.99999999999999e-08 0 1.001e-07 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.04e-07 1 1.0405e-07 0 1.05e-07 0 1.0505e-07 0 1.06e-07 0 1.061e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.1e-07 1 1.1005e-07 0 1.11e-07 0 1.1105e-07 0 1.12e-07 0 1.121e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.16e-07 1 1.1605e-07 0 1.17e-07 0 1.1705e-07 0 1.18e-07 0 1.181e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.22e-07 1 1.2205e-07 0 1.23e-07 0 1.2305e-07 0 1.24e-07 0 1.241e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.28e-07 1 1.2805e-07 0 1.29e-07 0 1.2905e-07 0 1.3e-07 0 1.301e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.34e-07 1 1.3405e-07 0 1.35e-07 0 1.3505e-07 0 1.36e-07 0 1.361e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.4e-07 1 1.4005e-07 0 1.41e-07 0 1.4105e-07 0 1.42e-07 0 1.421e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.46e-07 1 1.4605e-07 0 1.47e-07 0 1.4705e-07 0 1.48e-07 0 1.481e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.52e-07 1 1.5205e-07 0 1.53e-07 0 1.5305e-07 0 1.54e-07 0 1.541e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.58e-07 1 1.5805e-07 0 1.59e-07 0 1.5905e-07 0 1.6e-07 0 1.601e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.64e-07 1 1.6405e-07 0 1.65e-07 0 1.6505e-07 0 1.66e-07 0 1.661e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.7e-07 1 1.7005e-07 0 1.71e-07 0 1.7105e-07 0 1.72e-07 0 1.721e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.76e-07 1 1.7605e-07 0 1.77e-07 0 1.7705e-07 0 1.78e-07 0 1.781e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.82e-07 1 1.8205e-07 0 1.83e-07 0 1.8305e-07 0 1.84e-07 0 1.841e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.88e-07 1 1.8805e-07 0 1.89e-07 0 1.8905e-07 0 1.9e-07 0 1.901e-07 1 1.91e-07 1 1.9105e-07 0 1.91999999999999e-07 0 1.92049999999999e-07 0 1.92999999999999e-07 0 1.93099999999999e-07 1 1.93999999999999e-07 1 1.94049999999999e-07 0 1.94999999999999e-07 0 1.95049999999999e-07 0 1.95999999999999e-07 0 1.96099999999999e-07 1 1.96999999999999e-07 1 1.97049999999999e-07 0 1.97999999999999e-07 0 1.98049999999999e-07 0 1.98999999999999e-07 0 1.99099999999999e-07 1 1.99999999999999e-07 1 2.00049999999999e-07 0 2.00999999999999e-07 0 2.01049999999999e-07 0 2.01999999999999e-07 0 2.02099999999999e-07 1 2.02999999999999e-07 1 2.03049999999999e-07 0 2.03999999999999e-07 0 2.04049999999999e-07 0 2.04999999999999e-07 0 2.05099999999999e-07 1 2.05999999999999e-07 1 2.06049999999999e-07 0 2.06999999999999e-07 0 2.07049999999999e-07 0 2.07999999999999e-07 0 2.08099999999999e-07 1 2.08999999999999e-07 1 2.09049999999999e-07 0 2.09999999999999e-07 0 2.10049999999999e-07 0 2.10999999999999e-07 0 2.11099999999999e-07 1 2.11999999999999e-07 1 2.12049999999999e-07 0 2.12999999999999e-07 0 2.13049999999999e-07 0 2.13999999999999e-07 0 2.14099999999999e-07 1 2.14999999999999e-07 1 2.15049999999999e-07 0 2.15999999999999e-07 0 2.16049999999999e-07 0 2.16999999999999e-07 0 2.17099999999999e-07 1 2.17999999999999e-07 1 2.18049999999999e-07 0 2.18999999999999e-07 0 2.19049999999999e-07 0 2.19999999999999e-07 0 2.20099999999999e-07 1 2.20999999999999e-07 1 2.21049999999999e-07 0 2.21999999999999e-07 0 2.22049999999999e-07 0 2.22999999999999e-07 0 2.23099999999999e-07 1 2.23999999999999e-07 1 2.24049999999999e-07 0 2.24999999999999e-07 0 2.25049999999999e-07 0 2.25999999999999e-07 0 2.26099999999999e-07 1 2.26999999999999e-07 1 2.27049999999999e-07 0 2.27999999999999e-07 0 2.28049999999999e-07 0 2.28999999999999e-07 0 2.29099999999999e-07 1 2.29999999999999e-07 1 2.30049999999999e-07 0 2.30999999999999e-07 0 2.31049999999999e-07 0 2.31999999999999e-07 0 2.32099999999999e-07 1 2.32999999999999e-07 1 2.33049999999999e-07 0 2.33999999999999e-07 0 2.34049999999999e-07 0 2.34999999999999e-07 0 2.35099999999999e-07 1 2.35999999999999e-07 1 2.36049999999999e-07 0 2.36999999999999e-07 0 2.37049999999999e-07 0 2.37999999999999e-07 0 2.38099999999999e-07 1 2.38999999999999e-07 1 2.39049999999999e-07 0 2.39999999999999e-07 0 2.40049999999999e-07 0 2.40999999999999e-07 0 2.41099999999999e-07 1 2.41999999999999e-07 1 2.42049999999999e-07 0 2.42999999999999e-07 0 2.43049999999999e-07 0 2.43999999999999e-07 0 2.44099999999999e-07 1 2.44999999999999e-07 1 2.45049999999999e-07 0 2.45999999999999e-07 0 2.46049999999999e-07 0 2.46999999999999e-07 0 2.471e-07 1 2.48e-07 1 2.4805e-07 0 2.49e-07 0 2.4905e-07 0 2.5e-07 0 2.501e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.54e-07 1 2.5405e-07 0 2.55e-07 0 2.5505e-07 0 2.56e-07 0 2.561e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.6e-07 1 2.6005e-07 0 2.61e-07 0 2.6105e-07 0 2.62e-07 0 2.621e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.66e-07 1 2.6605e-07 0 2.67e-07 0 2.6705e-07 0 2.68e-07 0 2.681e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.72e-07 1 2.7205e-07 0 2.73e-07 0 2.7305e-07 0 2.74e-07 0 2.741e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.78e-07 1 2.7805e-07 0 2.79e-07 0 2.7905e-07 0 2.8e-07 0 2.801e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.84e-07 1 2.8405e-07 0 2.85e-07 0 2.8505e-07 0 2.86e-07 0 2.861e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.9e-07 1 2.9005e-07 0 2.91e-07 0 2.9105e-07 0 2.92e-07 0 2.92100000000001e-07 1 2.93000000000001e-07 1 2.93050000000001e-07 0 2.94000000000001e-07 0 2.94050000000001e-07 0 2.95000000000001e-07 0 2.95100000000001e-07 1 2.96000000000001e-07 1 2.96050000000001e-07 0 2.97000000000001e-07 0 2.97050000000001e-07 0 2.98000000000001e-07 0 2.98100000000001e-07 1 2.99000000000001e-07 1 2.99050000000001e-07 0 3.00000000000001e-07 0 3.00050000000001e-07 0 3.01000000000001e-07 0 3.01100000000001e-07 1 3.02000000000001e-07 1 3.02050000000001e-07 0 3.03000000000001e-07 0 3.03050000000001e-07 0 3.04000000000001e-07 0 3.04100000000001e-07 1 3.05000000000001e-07 1 3.05050000000001e-07 0 3.06000000000001e-07 0 3.06050000000001e-07 0 3.07000000000001e-07 0 3.07100000000001e-07 1 3.08000000000001e-07 1 3.08050000000001e-07 0 3.09000000000001e-07 0 3.09050000000001e-07 0 3.10000000000001e-07 0 3.10100000000001e-07 1 3.11000000000001e-07 1 3.11050000000001e-07 0 3.12000000000001e-07 0 3.12050000000001e-07 0 3.13000000000001e-07 0 3.13100000000001e-07 1 3.14000000000001e-07 1 3.14050000000001e-07 0 3.15000000000001e-07 0 3.15050000000001e-07 0 3.16000000000001e-07 0 3.16100000000001e-07 1 3.17000000000001e-07 1 3.17050000000001e-07 0 3.18000000000001e-07 0 3.18050000000001e-07 0 3.19000000000001e-07 0 3.19100000000001e-07 1 3.20000000000001e-07 1 3.20050000000001e-07 0 3.21000000000001e-07 0 3.21050000000001e-07 0 3.22000000000001e-07 0 3.22100000000001e-07 1 3.23000000000001e-07 1 3.23050000000001e-07 0 3.24000000000001e-07 0 3.24050000000001e-07 0 3.25000000000001e-07 0 3.25100000000001e-07 1 3.26000000000001e-07 1 3.26050000000001e-07 0 3.27000000000001e-07 0 3.27050000000001e-07 0 3.28000000000001e-07 0 3.28100000000001e-07 1 3.29000000000001e-07 1 3.29050000000001e-07 0 3.30000000000001e-07 0 3.30050000000001e-07 0 3.31000000000001e-07 0 3.31100000000001e-07 1 3.32000000000001e-07 1 3.32050000000001e-07 0 3.33000000000001e-07 0 3.33050000000001e-07 0 3.34000000000001e-07 0 3.34100000000001e-07 1 3.35000000000001e-07 1 3.35050000000001e-07 0 3.36000000000001e-07 0 3.36050000000001e-07 0 3.37000000000001e-07 0 3.37100000000002e-07 1 3.38000000000002e-07 1 3.38050000000002e-07 0 3.39000000000002e-07 0 3.39050000000002e-07 0 3.40000000000002e-07 0 3.40100000000002e-07 1 3.41000000000002e-07 1 3.41050000000002e-07 0 3.42000000000002e-07 0 3.42050000000002e-07 0 3.43000000000002e-07 0 3.43100000000002e-07 1 3.44000000000002e-07 1 3.44050000000002e-07 0 3.45000000000002e-07 0 3.45050000000002e-07 0 3.46000000000002e-07 0 3.46100000000002e-07 1 3.47000000000002e-07 1 3.47050000000002e-07 0 3.48000000000002e-07 0 3.48050000000002e-07 0 3.49000000000002e-07 0 3.49100000000002e-07 1 3.50000000000002e-07 1 3.50050000000002e-07 0 3.51000000000002e-07 0 3.51050000000002e-07 0 3.52000000000002e-07 0 3.52100000000002e-07 1 3.53000000000002e-07 1 3.53050000000002e-07 0 3.54000000000002e-07 0 3.54050000000002e-07 0 3.55000000000002e-07 0 3.55100000000002e-07 1 3.56000000000002e-07 1 3.56050000000002e-07 0 3.57000000000002e-07 0 3.57050000000002e-07 0 3.58000000000002e-07 0 3.58100000000002e-07 1 3.59000000000002e-07 1 3.59050000000002e-07 0 3.60000000000002e-07 0 3.60050000000002e-07 0 3.61000000000002e-07 0 3.61100000000002e-07 1 3.62000000000002e-07 1 3.62050000000002e-07 0 3.63000000000002e-07 0 3.63050000000002e-07 0 3.64000000000002e-07 0 3.64100000000002e-07 1 3.65000000000002e-07 1 3.65050000000002e-07 0 3.66000000000002e-07 0 3.66050000000002e-07 0 3.67000000000002e-07 0 3.67100000000002e-07 1 3.68000000000002e-07 1 3.68050000000002e-07 0 3.69000000000002e-07 0 3.69050000000002e-07 0 3.70000000000002e-07 0 3.70100000000002e-07 1 3.71000000000002e-07 1 3.71050000000002e-07 0 3.72000000000002e-07 0 3.72050000000002e-07 0 3.73000000000002e-07 0 3.73100000000002e-07 1 3.74000000000002e-07 1 3.74050000000002e-07 0 3.75000000000002e-07 0 3.75050000000002e-07 0 3.76000000000002e-07 0 3.76100000000002e-07 1 3.77000000000002e-07 1 3.77050000000002e-07 0 3.78000000000002e-07 0 3.78050000000002e-07 0 3.79000000000002e-07 0 3.79100000000002e-07 1 3.80000000000002e-07 1 3.80050000000002e-07 0 3.81000000000002e-07 0 3.81050000000002e-07 0 3.82000000000002e-07 0 3.82100000000003e-07 1 3.83000000000003e-07 1 3.83050000000003e-07 0 3.88500000000003e-07 0]
