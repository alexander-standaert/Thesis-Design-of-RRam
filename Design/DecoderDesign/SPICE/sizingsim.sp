simulator lang=spectre

include "transistorsPTM.scs"
include "../../ArchitectureDesign/SPICE/decoder.sp"
include "parameters2.sp"

xdecoder (IN_0 IN_1 IN_2 IN_3 IN_4 IN_5 IN_6 IN_7 enable TEMP_0_0 TEMP_0_1 TEMP_0_2 TEMP_0_3 TEMP_0_4 TEMP_0_5 TEMP_0_6 TEMP_0_7 TEMP_0_8 TEMP_0_9 TEMP_0_10 TEMP_0_11 TEMP_0_12 TEMP_0_13 TEMP_0_14 TEMP_0_15 TEMP_0_16 TEMP_0_17 TEMP_0_18 TEMP_0_19 TEMP_0_20 TEMP_0_21 TEMP_0_22 TEMP_0_23 TEMP_0_24 TEMP_0_25 TEMP_0_26 TEMP_0_27 TEMP_0_28 TEMP_0_29 TEMP_0_30 TEMP_0_31 TEMP_0_32 TEMP_0_33 TEMP_0_34 TEMP_0_35 TEMP_0_36 TEMP_0_37 TEMP_0_38 TEMP_0_39 TEMP_0_40 TEMP_0_41 TEMP_0_42 TEMP_0_43 TEMP_0_44 TEMP_0_45 TEMP_0_46 TEMP_0_47 TEMP_0_48 TEMP_0_49 TEMP_0_50 TEMP_0_51 TEMP_0_52 TEMP_0_53 TEMP_0_54 TEMP_0_55 TEMP_0_56 TEMP_0_57 TEMP_0_58 TEMP_0_59 TEMP_0_60 TEMP_0_61 TEMP_0_62 TEMP_0_63 TEMP_0_64 TEMP_0_65 TEMP_0_66 TEMP_0_67 TEMP_0_68 TEMP_0_69 TEMP_0_70 TEMP_0_71 TEMP_0_72 TEMP_0_73 TEMP_0_74 TEMP_0_75 TEMP_0_76 TEMP_0_77 TEMP_0_78 TEMP_0_79 TEMP_0_80 TEMP_0_81 TEMP_0_82 TEMP_0_83 TEMP_0_84 TEMP_0_85 TEMP_0_86 TEMP_0_87 TEMP_0_88 TEMP_0_89 TEMP_0_90 TEMP_0_91 TEMP_0_92 TEMP_0_93 TEMP_0_94 TEMP_0_95 TEMP_0_96 TEMP_0_97 TEMP_0_98 TEMP_0_99 TEMP_0_100 TEMP_0_101 TEMP_0_102 TEMP_0_103 TEMP_0_104 TEMP_0_105 TEMP_0_106 TEMP_0_107 TEMP_0_108 TEMP_0_109 TEMP_0_110 TEMP_0_111 TEMP_0_112 TEMP_0_113 TEMP_0_114 TEMP_0_115 TEMP_0_116 TEMP_0_117 TEMP_0_118 TEMP_0_119 TEMP_0_120 TEMP_0_121 TEMP_0_122 TEMP_0_123 TEMP_0_124 TEMP_0_125 TEMP_0_126 TEMP_0_127 TEMP_0_128 TEMP_0_129 TEMP_0_130 TEMP_0_131 TEMP_0_132 TEMP_0_133 TEMP_0_134 TEMP_0_135 TEMP_0_136 TEMP_0_137 TEMP_0_138 TEMP_0_139 TEMP_0_140 TEMP_0_141 TEMP_0_142 TEMP_0_143 TEMP_0_144 TEMP_0_145 TEMP_0_146 TEMP_0_147 TEMP_0_148 TEMP_0_149 TEMP_0_150 TEMP_0_151 TEMP_0_152 TEMP_0_153 TEMP_0_154 TEMP_0_155 TEMP_0_156 TEMP_0_157 TEMP_0_158 TEMP_0_159 TEMP_0_160 TEMP_0_161 TEMP_0_162 TEMP_0_163 TEMP_0_164 TEMP_0_165 TEMP_0_166 TEMP_0_167 TEMP_0_168 TEMP_0_169 TEMP_0_170 TEMP_0_171 TEMP_0_172 TEMP_0_173 TEMP_0_174 TEMP_0_175 TEMP_0_176 TEMP_0_177 TEMP_0_178 TEMP_0_179 TEMP_0_180 TEMP_0_181 TEMP_0_182 TEMP_0_183 TEMP_0_184 TEMP_0_185 TEMP_0_186 TEMP_0_187 TEMP_0_188 TEMP_0_189 TEMP_0_190 TEMP_0_191 TEMP_0_192 TEMP_0_193 TEMP_0_194 TEMP_0_195 TEMP_0_196 TEMP_0_197 TEMP_0_198 TEMP_0_199 TEMP_0_200 TEMP_0_201 TEMP_0_202 TEMP_0_203 TEMP_0_204 TEMP_0_205 TEMP_0_206 TEMP_0_207 TEMP_0_208 TEMP_0_209 TEMP_0_210 TEMP_0_211 TEMP_0_212 TEMP_0_213 TEMP_0_214 TEMP_0_215 TEMP_0_216 TEMP_0_217 TEMP_0_218 TEMP_0_219 TEMP_0_220 TEMP_0_221 TEMP_0_222 TEMP_0_223 TEMP_0_224 TEMP_0_225 TEMP_0_226 TEMP_0_227 TEMP_0_228 TEMP_0_229 TEMP_0_230 TEMP_0_231 TEMP_0_232 TEMP_0_233 TEMP_0_234 TEMP_0_235 TEMP_0_236 TEMP_0_237 TEMP_0_238 TEMP_0_239 TEMP_0_240 TEMP_0_241 TEMP_0_242 TEMP_0_243 TEMP_0_244 TEMP_0_245 TEMP_0_246 TEMP_0_247 TEMP_0_248 TEMP_0_249 TEMP_0_250 TEMP_0_251 TEMP_0_252 TEMP_0_253 TEMP_0_254 TEMP_0_255 vdd vss NBulkLine PBulkLine) decodereight // multstage_1 = dec1multstage_1 multstage_2 = dec1multstage_2 multstage_3 = dec1multstage_3 multstage_4 = dec1multstage_4 multstage_5 = dec1multstage_5 multstage_6 = dec1multstage_6 multstage_7 = dec1multstage_7
cLoad0 (OUT_0 0) capacitor c=2.88e-15
cLoad1 (OUT_1 0) capacitor c=2.88e-15
cLoad2 (OUT_2 0) capacitor c=2.88e-15
cLoad3 (OUT_3 0) capacitor c=2.88e-15
cLoad4 (OUT_4 0) capacitor c=2.88e-15
cLoad5 (OUT_5 0) capacitor c=2.88e-15
cLoad6 (OUT_6 0) capacitor c=2.88e-15
cLoad7 (OUT_7 0) capacitor c=2.88e-15
cLoad8 (OUT_8 0) capacitor c=2.88e-15
cLoad9 (OUT_9 0) capacitor c=2.88e-15
cLoad10 (OUT_10 0) capacitor c=2.88e-15
cLoad11 (OUT_11 0) capacitor c=2.88e-15
cLoad12 (OUT_12 0) capacitor c=2.88e-15
cLoad13 (OUT_13 0) capacitor c=2.88e-15
cLoad14 (OUT_14 0) capacitor c=2.88e-15
cLoad15 (OUT_15 0) capacitor c=2.88e-15
cLoad16 (OUT_16 0) capacitor c=2.88e-15
cLoad17 (OUT_17 0) capacitor c=2.88e-15
cLoad18 (OUT_18 0) capacitor c=2.88e-15
cLoad19 (OUT_19 0) capacitor c=2.88e-15
cLoad20 (OUT_20 0) capacitor c=2.88e-15
cLoad21 (OUT_21 0) capacitor c=2.88e-15
cLoad22 (OUT_22 0) capacitor c=2.88e-15
cLoad23 (OUT_23 0) capacitor c=2.88e-15
cLoad24 (OUT_24 0) capacitor c=2.88e-15
cLoad25 (OUT_25 0) capacitor c=2.88e-15
cLoad26 (OUT_26 0) capacitor c=2.88e-15
cLoad27 (OUT_27 0) capacitor c=2.88e-15
cLoad28 (OUT_28 0) capacitor c=2.88e-15
cLoad29 (OUT_29 0) capacitor c=2.88e-15
cLoad30 (OUT_30 0) capacitor c=2.88e-15
cLoad31 (OUT_31 0) capacitor c=2.88e-15
cLoad32 (OUT_32 0) capacitor c=2.88e-15
cLoad33 (OUT_33 0) capacitor c=2.88e-15
cLoad34 (OUT_34 0) capacitor c=2.88e-15
cLoad35 (OUT_35 0) capacitor c=2.88e-15
cLoad36 (OUT_36 0) capacitor c=2.88e-15
cLoad37 (OUT_37 0) capacitor c=2.88e-15
cLoad38 (OUT_38 0) capacitor c=2.88e-15
cLoad39 (OUT_39 0) capacitor c=2.88e-15
cLoad40 (OUT_40 0) capacitor c=2.88e-15
cLoad41 (OUT_41 0) capacitor c=2.88e-15
cLoad42 (OUT_42 0) capacitor c=2.88e-15
cLoad43 (OUT_43 0) capacitor c=2.88e-15
cLoad44 (OUT_44 0) capacitor c=2.88e-15
cLoad45 (OUT_45 0) capacitor c=2.88e-15
cLoad46 (OUT_46 0) capacitor c=2.88e-15
cLoad47 (OUT_47 0) capacitor c=2.88e-15
cLoad48 (OUT_48 0) capacitor c=2.88e-15
cLoad49 (OUT_49 0) capacitor c=2.88e-15
cLoad50 (OUT_50 0) capacitor c=2.88e-15
cLoad51 (OUT_51 0) capacitor c=2.88e-15
cLoad52 (OUT_52 0) capacitor c=2.88e-15
cLoad53 (OUT_53 0) capacitor c=2.88e-15
cLoad54 (OUT_54 0) capacitor c=2.88e-15
cLoad55 (OUT_55 0) capacitor c=2.88e-15
cLoad56 (OUT_56 0) capacitor c=2.88e-15
cLoad57 (OUT_57 0) capacitor c=2.88e-15
cLoad58 (OUT_58 0) capacitor c=2.88e-15
cLoad59 (OUT_59 0) capacitor c=2.88e-15
cLoad60 (OUT_60 0) capacitor c=2.88e-15
cLoad61 (OUT_61 0) capacitor c=2.88e-15
cLoad62 (OUT_62 0) capacitor c=2.88e-15
cLoad63 (OUT_63 0) capacitor c=2.88e-15
cLoad64 (OUT_64 0) capacitor c=2.88e-15
cLoad65 (OUT_65 0) capacitor c=2.88e-15
cLoad66 (OUT_66 0) capacitor c=2.88e-15
cLoad67 (OUT_67 0) capacitor c=2.88e-15
cLoad68 (OUT_68 0) capacitor c=2.88e-15
cLoad69 (OUT_69 0) capacitor c=2.88e-15
cLoad70 (OUT_70 0) capacitor c=2.88e-15
cLoad71 (OUT_71 0) capacitor c=2.88e-15
cLoad72 (OUT_72 0) capacitor c=2.88e-15
cLoad73 (OUT_73 0) capacitor c=2.88e-15
cLoad74 (OUT_74 0) capacitor c=2.88e-15
cLoad75 (OUT_75 0) capacitor c=2.88e-15
cLoad76 (OUT_76 0) capacitor c=2.88e-15
cLoad77 (OUT_77 0) capacitor c=2.88e-15
cLoad78 (OUT_78 0) capacitor c=2.88e-15
cLoad79 (OUT_79 0) capacitor c=2.88e-15
cLoad80 (OUT_80 0) capacitor c=2.88e-15
cLoad81 (OUT_81 0) capacitor c=2.88e-15
cLoad82 (OUT_82 0) capacitor c=2.88e-15
cLoad83 (OUT_83 0) capacitor c=2.88e-15
cLoad84 (OUT_84 0) capacitor c=2.88e-15
cLoad85 (OUT_85 0) capacitor c=2.88e-15
cLoad86 (OUT_86 0) capacitor c=2.88e-15
cLoad87 (OUT_87 0) capacitor c=2.88e-15
cLoad88 (OUT_88 0) capacitor c=2.88e-15
cLoad89 (OUT_89 0) capacitor c=2.88e-15
cLoad90 (OUT_90 0) capacitor c=2.88e-15
cLoad91 (OUT_91 0) capacitor c=2.88e-15
cLoad92 (OUT_92 0) capacitor c=2.88e-15
cLoad93 (OUT_93 0) capacitor c=2.88e-15
cLoad94 (OUT_94 0) capacitor c=2.88e-15
cLoad95 (OUT_95 0) capacitor c=2.88e-15
cLoad96 (OUT_96 0) capacitor c=2.88e-15
cLoad97 (OUT_97 0) capacitor c=2.88e-15
cLoad98 (OUT_98 0) capacitor c=2.88e-15
cLoad99 (OUT_99 0) capacitor c=2.88e-15
cLoad100 (OUT_100 0) capacitor c=2.88e-15
cLoad101 (OUT_101 0) capacitor c=2.88e-15
cLoad102 (OUT_102 0) capacitor c=2.88e-15
cLoad103 (OUT_103 0) capacitor c=2.88e-15
cLoad104 (OUT_104 0) capacitor c=2.88e-15
cLoad105 (OUT_105 0) capacitor c=2.88e-15
cLoad106 (OUT_106 0) capacitor c=2.88e-15
cLoad107 (OUT_107 0) capacitor c=2.88e-15
cLoad108 (OUT_108 0) capacitor c=2.88e-15
cLoad109 (OUT_109 0) capacitor c=2.88e-15
cLoad110 (OUT_110 0) capacitor c=2.88e-15
cLoad111 (OUT_111 0) capacitor c=2.88e-15
cLoad112 (OUT_112 0) capacitor c=2.88e-15
cLoad113 (OUT_113 0) capacitor c=2.88e-15
cLoad114 (OUT_114 0) capacitor c=2.88e-15
cLoad115 (OUT_115 0) capacitor c=2.88e-15
cLoad116 (OUT_116 0) capacitor c=2.88e-15
cLoad117 (OUT_117 0) capacitor c=2.88e-15
cLoad118 (OUT_118 0) capacitor c=2.88e-15
cLoad119 (OUT_119 0) capacitor c=2.88e-15
cLoad120 (OUT_120 0) capacitor c=2.88e-15
cLoad121 (OUT_121 0) capacitor c=2.88e-15
cLoad122 (OUT_122 0) capacitor c=2.88e-15
cLoad123 (OUT_123 0) capacitor c=2.88e-15
cLoad124 (OUT_124 0) capacitor c=2.88e-15
cLoad125 (OUT_125 0) capacitor c=2.88e-15
cLoad126 (OUT_126 0) capacitor c=2.88e-15
cLoad127 (OUT_127 0) capacitor c=2.88e-15
cLoad128 (OUT_128 0) capacitor c=2.88e-15
cLoad129 (OUT_129 0) capacitor c=2.88e-15
cLoad130 (OUT_130 0) capacitor c=2.88e-15
cLoad131 (OUT_131 0) capacitor c=2.88e-15
cLoad132 (OUT_132 0) capacitor c=2.88e-15
cLoad133 (OUT_133 0) capacitor c=2.88e-15
cLoad134 (OUT_134 0) capacitor c=2.88e-15
cLoad135 (OUT_135 0) capacitor c=2.88e-15
cLoad136 (OUT_136 0) capacitor c=2.88e-15
cLoad137 (OUT_137 0) capacitor c=2.88e-15
cLoad138 (OUT_138 0) capacitor c=2.88e-15
cLoad139 (OUT_139 0) capacitor c=2.88e-15
cLoad140 (OUT_140 0) capacitor c=2.88e-15
cLoad141 (OUT_141 0) capacitor c=2.88e-15
cLoad142 (OUT_142 0) capacitor c=2.88e-15
cLoad143 (OUT_143 0) capacitor c=2.88e-15
cLoad144 (OUT_144 0) capacitor c=2.88e-15
cLoad145 (OUT_145 0) capacitor c=2.88e-15
cLoad146 (OUT_146 0) capacitor c=2.88e-15
cLoad147 (OUT_147 0) capacitor c=2.88e-15
cLoad148 (OUT_148 0) capacitor c=2.88e-15
cLoad149 (OUT_149 0) capacitor c=2.88e-15
cLoad150 (OUT_150 0) capacitor c=2.88e-15
cLoad151 (OUT_151 0) capacitor c=2.88e-15
cLoad152 (OUT_152 0) capacitor c=2.88e-15
cLoad153 (OUT_153 0) capacitor c=2.88e-15
cLoad154 (OUT_154 0) capacitor c=2.88e-15
cLoad155 (OUT_155 0) capacitor c=2.88e-15
cLoad156 (OUT_156 0) capacitor c=2.88e-15
cLoad157 (OUT_157 0) capacitor c=2.88e-15
cLoad158 (OUT_158 0) capacitor c=2.88e-15
cLoad159 (OUT_159 0) capacitor c=2.88e-15
cLoad160 (OUT_160 0) capacitor c=2.88e-15
cLoad161 (OUT_161 0) capacitor c=2.88e-15
cLoad162 (OUT_162 0) capacitor c=2.88e-15
cLoad163 (OUT_163 0) capacitor c=2.88e-15
cLoad164 (OUT_164 0) capacitor c=2.88e-15
cLoad165 (OUT_165 0) capacitor c=2.88e-15
cLoad166 (OUT_166 0) capacitor c=2.88e-15
cLoad167 (OUT_167 0) capacitor c=2.88e-15
cLoad168 (OUT_168 0) capacitor c=2.88e-15
cLoad169 (OUT_169 0) capacitor c=2.88e-15
cLoad170 (OUT_170 0) capacitor c=2.88e-15
cLoad171 (OUT_171 0) capacitor c=2.88e-15
cLoad172 (OUT_172 0) capacitor c=2.88e-15
cLoad173 (OUT_173 0) capacitor c=2.88e-15
cLoad174 (OUT_174 0) capacitor c=2.88e-15
cLoad175 (OUT_175 0) capacitor c=2.88e-15
cLoad176 (OUT_176 0) capacitor c=2.88e-15
cLoad177 (OUT_177 0) capacitor c=2.88e-15
cLoad178 (OUT_178 0) capacitor c=2.88e-15
cLoad179 (OUT_179 0) capacitor c=2.88e-15
cLoad180 (OUT_180 0) capacitor c=2.88e-15
cLoad181 (OUT_181 0) capacitor c=2.88e-15
cLoad182 (OUT_182 0) capacitor c=2.88e-15
cLoad183 (OUT_183 0) capacitor c=2.88e-15
cLoad184 (OUT_184 0) capacitor c=2.88e-15
cLoad185 (OUT_185 0) capacitor c=2.88e-15
cLoad186 (OUT_186 0) capacitor c=2.88e-15
cLoad187 (OUT_187 0) capacitor c=2.88e-15
cLoad188 (OUT_188 0) capacitor c=2.88e-15
cLoad189 (OUT_189 0) capacitor c=2.88e-15
cLoad190 (OUT_190 0) capacitor c=2.88e-15
cLoad191 (OUT_191 0) capacitor c=2.88e-15
cLoad192 (OUT_192 0) capacitor c=2.88e-15
cLoad193 (OUT_193 0) capacitor c=2.88e-15
cLoad194 (OUT_194 0) capacitor c=2.88e-15
cLoad195 (OUT_195 0) capacitor c=2.88e-15
cLoad196 (OUT_196 0) capacitor c=2.88e-15
cLoad197 (OUT_197 0) capacitor c=2.88e-15
cLoad198 (OUT_198 0) capacitor c=2.88e-15
cLoad199 (OUT_199 0) capacitor c=2.88e-15
cLoad200 (OUT_200 0) capacitor c=2.88e-15
cLoad201 (OUT_201 0) capacitor c=2.88e-15
cLoad202 (OUT_202 0) capacitor c=2.88e-15
cLoad203 (OUT_203 0) capacitor c=2.88e-15
cLoad204 (OUT_204 0) capacitor c=2.88e-15
cLoad205 (OUT_205 0) capacitor c=2.88e-15
cLoad206 (OUT_206 0) capacitor c=2.88e-15
cLoad207 (OUT_207 0) capacitor c=2.88e-15
cLoad208 (OUT_208 0) capacitor c=2.88e-15
cLoad209 (OUT_209 0) capacitor c=2.88e-15
cLoad210 (OUT_210 0) capacitor c=2.88e-15
cLoad211 (OUT_211 0) capacitor c=2.88e-15
cLoad212 (OUT_212 0) capacitor c=2.88e-15
cLoad213 (OUT_213 0) capacitor c=2.88e-15
cLoad214 (OUT_214 0) capacitor c=2.88e-15
cLoad215 (OUT_215 0) capacitor c=2.88e-15
cLoad216 (OUT_216 0) capacitor c=2.88e-15
cLoad217 (OUT_217 0) capacitor c=2.88e-15
cLoad218 (OUT_218 0) capacitor c=2.88e-15
cLoad219 (OUT_219 0) capacitor c=2.88e-15
cLoad220 (OUT_220 0) capacitor c=2.88e-15
cLoad221 (OUT_221 0) capacitor c=2.88e-15
cLoad222 (OUT_222 0) capacitor c=2.88e-15
cLoad223 (OUT_223 0) capacitor c=2.88e-15
cLoad224 (OUT_224 0) capacitor c=2.88e-15
cLoad225 (OUT_225 0) capacitor c=2.88e-15
cLoad226 (OUT_226 0) capacitor c=2.88e-15
cLoad227 (OUT_227 0) capacitor c=2.88e-15
cLoad228 (OUT_228 0) capacitor c=2.88e-15
cLoad229 (OUT_229 0) capacitor c=2.88e-15
cLoad230 (OUT_230 0) capacitor c=2.88e-15
cLoad231 (OUT_231 0) capacitor c=2.88e-15
cLoad232 (OUT_232 0) capacitor c=2.88e-15
cLoad233 (OUT_233 0) capacitor c=2.88e-15
cLoad234 (OUT_234 0) capacitor c=2.88e-15
cLoad235 (OUT_235 0) capacitor c=2.88e-15
cLoad236 (OUT_236 0) capacitor c=2.88e-15
cLoad237 (OUT_237 0) capacitor c=2.88e-15
cLoad238 (OUT_238 0) capacitor c=2.88e-15
cLoad239 (OUT_239 0) capacitor c=2.88e-15
cLoad240 (OUT_240 0) capacitor c=2.88e-15
cLoad241 (OUT_241 0) capacitor c=2.88e-15
cLoad242 (OUT_242 0) capacitor c=2.88e-15
cLoad243 (OUT_243 0) capacitor c=2.88e-15
cLoad244 (OUT_244 0) capacitor c=2.88e-15
cLoad245 (OUT_245 0) capacitor c=2.88e-15
cLoad246 (OUT_246 0) capacitor c=2.88e-15
cLoad247 (OUT_247 0) capacitor c=2.88e-15
cLoad248 (OUT_248 0) capacitor c=2.88e-15
cLoad249 (OUT_249 0) capacitor c=2.88e-15
cLoad250 (OUT_250 0) capacitor c=2.88e-15
cLoad251 (OUT_251 0) capacitor c=2.88e-15
cLoad252 (OUT_252 0) capacitor c=2.88e-15
cLoad253 (OUT_253 0) capacitor c=2.88e-15
cLoad254 (OUT_254 0) capacitor c=2.88e-15
cLoad255 (OUT_255 0) capacitor c=2.88e-15

xNOT_0_0 (TEMP_0_0 TEMP_1_0 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_1 (TEMP_0_1 TEMP_1_1 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_2 (TEMP_0_2 TEMP_1_2 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_3 (TEMP_0_3 TEMP_1_3 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_4 (TEMP_0_4 TEMP_1_4 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_5 (TEMP_0_5 TEMP_1_5 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_6 (TEMP_0_6 TEMP_1_6 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_7 (TEMP_0_7 TEMP_1_7 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_8 (TEMP_0_8 TEMP_1_8 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_9 (TEMP_0_9 TEMP_1_9 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_10 (TEMP_0_10 TEMP_1_10 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_11 (TEMP_0_11 TEMP_1_11 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_12 (TEMP_0_12 TEMP_1_12 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_13 (TEMP_0_13 TEMP_1_13 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_14 (TEMP_0_14 TEMP_1_14 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_15 (TEMP_0_15 TEMP_1_15 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_16 (TEMP_0_16 TEMP_1_16 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_17 (TEMP_0_17 TEMP_1_17 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_18 (TEMP_0_18 TEMP_1_18 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_19 (TEMP_0_19 TEMP_1_19 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_20 (TEMP_0_20 TEMP_1_20 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_21 (TEMP_0_21 TEMP_1_21 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_22 (TEMP_0_22 TEMP_1_22 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_23 (TEMP_0_23 TEMP_1_23 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_24 (TEMP_0_24 TEMP_1_24 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_25 (TEMP_0_25 TEMP_1_25 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_26 (TEMP_0_26 TEMP_1_26 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_27 (TEMP_0_27 TEMP_1_27 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_28 (TEMP_0_28 TEMP_1_28 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_29 (TEMP_0_29 TEMP_1_29 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_30 (TEMP_0_30 TEMP_1_30 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_31 (TEMP_0_31 TEMP_1_31 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_32 (TEMP_0_32 TEMP_1_32 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_33 (TEMP_0_33 TEMP_1_33 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_34 (TEMP_0_34 TEMP_1_34 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_35 (TEMP_0_35 TEMP_1_35 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_36 (TEMP_0_36 TEMP_1_36 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_37 (TEMP_0_37 TEMP_1_37 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_38 (TEMP_0_38 TEMP_1_38 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_39 (TEMP_0_39 TEMP_1_39 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_40 (TEMP_0_40 TEMP_1_40 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_41 (TEMP_0_41 TEMP_1_41 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_42 (TEMP_0_42 TEMP_1_42 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_43 (TEMP_0_43 TEMP_1_43 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_44 (TEMP_0_44 TEMP_1_44 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_45 (TEMP_0_45 TEMP_1_45 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_46 (TEMP_0_46 TEMP_1_46 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_47 (TEMP_0_47 TEMP_1_47 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_48 (TEMP_0_48 TEMP_1_48 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_49 (TEMP_0_49 TEMP_1_49 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_50 (TEMP_0_50 TEMP_1_50 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_51 (TEMP_0_51 TEMP_1_51 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_52 (TEMP_0_52 TEMP_1_52 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_53 (TEMP_0_53 TEMP_1_53 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_54 (TEMP_0_54 TEMP_1_54 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_55 (TEMP_0_55 TEMP_1_55 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_56 (TEMP_0_56 TEMP_1_56 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_57 (TEMP_0_57 TEMP_1_57 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_58 (TEMP_0_58 TEMP_1_58 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_59 (TEMP_0_59 TEMP_1_59 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_60 (TEMP_0_60 TEMP_1_60 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_61 (TEMP_0_61 TEMP_1_61 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_62 (TEMP_0_62 TEMP_1_62 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_63 (TEMP_0_63 TEMP_1_63 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_64 (TEMP_0_64 TEMP_1_64 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_65 (TEMP_0_65 TEMP_1_65 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_66 (TEMP_0_66 TEMP_1_66 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_67 (TEMP_0_67 TEMP_1_67 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_68 (TEMP_0_68 TEMP_1_68 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_69 (TEMP_0_69 TEMP_1_69 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_70 (TEMP_0_70 TEMP_1_70 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_71 (TEMP_0_71 TEMP_1_71 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_72 (TEMP_0_72 TEMP_1_72 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_73 (TEMP_0_73 TEMP_1_73 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_74 (TEMP_0_74 TEMP_1_74 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_75 (TEMP_0_75 TEMP_1_75 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_76 (TEMP_0_76 TEMP_1_76 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_77 (TEMP_0_77 TEMP_1_77 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_78 (TEMP_0_78 TEMP_1_78 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_79 (TEMP_0_79 TEMP_1_79 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_80 (TEMP_0_80 TEMP_1_80 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_81 (TEMP_0_81 TEMP_1_81 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_82 (TEMP_0_82 TEMP_1_82 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_83 (TEMP_0_83 TEMP_1_83 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_84 (TEMP_0_84 TEMP_1_84 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_85 (TEMP_0_85 TEMP_1_85 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_86 (TEMP_0_86 TEMP_1_86 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_87 (TEMP_0_87 TEMP_1_87 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_88 (TEMP_0_88 TEMP_1_88 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_89 (TEMP_0_89 TEMP_1_89 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_90 (TEMP_0_90 TEMP_1_90 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_91 (TEMP_0_91 TEMP_1_91 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_92 (TEMP_0_92 TEMP_1_92 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_93 (TEMP_0_93 TEMP_1_93 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_94 (TEMP_0_94 TEMP_1_94 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_95 (TEMP_0_95 TEMP_1_95 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_96 (TEMP_0_96 TEMP_1_96 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_97 (TEMP_0_97 TEMP_1_97 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_98 (TEMP_0_98 TEMP_1_98 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_99 (TEMP_0_99 TEMP_1_99 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_100 (TEMP_0_100 TEMP_1_100 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_101 (TEMP_0_101 TEMP_1_101 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_102 (TEMP_0_102 TEMP_1_102 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_103 (TEMP_0_103 TEMP_1_103 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_104 (TEMP_0_104 TEMP_1_104 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_105 (TEMP_0_105 TEMP_1_105 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_106 (TEMP_0_106 TEMP_1_106 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_107 (TEMP_0_107 TEMP_1_107 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_108 (TEMP_0_108 TEMP_1_108 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_109 (TEMP_0_109 TEMP_1_109 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_110 (TEMP_0_110 TEMP_1_110 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_111 (TEMP_0_111 TEMP_1_111 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_112 (TEMP_0_112 TEMP_1_112 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_113 (TEMP_0_113 TEMP_1_113 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_114 (TEMP_0_114 TEMP_1_114 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_115 (TEMP_0_115 TEMP_1_115 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_116 (TEMP_0_116 TEMP_1_116 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_117 (TEMP_0_117 TEMP_1_117 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_118 (TEMP_0_118 TEMP_1_118 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_119 (TEMP_0_119 TEMP_1_119 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_120 (TEMP_0_120 TEMP_1_120 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_121 (TEMP_0_121 TEMP_1_121 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_122 (TEMP_0_122 TEMP_1_122 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_123 (TEMP_0_123 TEMP_1_123 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_124 (TEMP_0_124 TEMP_1_124 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_125 (TEMP_0_125 TEMP_1_125 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_126 (TEMP_0_126 TEMP_1_126 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_127 (TEMP_0_127 TEMP_1_127 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_128 (TEMP_0_128 TEMP_1_128 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_129 (TEMP_0_129 TEMP_1_129 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_130 (TEMP_0_130 TEMP_1_130 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_131 (TEMP_0_131 TEMP_1_131 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_132 (TEMP_0_132 TEMP_1_132 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_133 (TEMP_0_133 TEMP_1_133 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_134 (TEMP_0_134 TEMP_1_134 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_135 (TEMP_0_135 TEMP_1_135 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_136 (TEMP_0_136 TEMP_1_136 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_137 (TEMP_0_137 TEMP_1_137 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_138 (TEMP_0_138 TEMP_1_138 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_139 (TEMP_0_139 TEMP_1_139 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_140 (TEMP_0_140 TEMP_1_140 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_141 (TEMP_0_141 TEMP_1_141 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_142 (TEMP_0_142 TEMP_1_142 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_143 (TEMP_0_143 TEMP_1_143 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_144 (TEMP_0_144 TEMP_1_144 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_145 (TEMP_0_145 TEMP_1_145 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_146 (TEMP_0_146 TEMP_1_146 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_147 (TEMP_0_147 TEMP_1_147 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_148 (TEMP_0_148 TEMP_1_148 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_149 (TEMP_0_149 TEMP_1_149 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_150 (TEMP_0_150 TEMP_1_150 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_151 (TEMP_0_151 TEMP_1_151 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_152 (TEMP_0_152 TEMP_1_152 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_153 (TEMP_0_153 TEMP_1_153 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_154 (TEMP_0_154 TEMP_1_154 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_155 (TEMP_0_155 TEMP_1_155 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_156 (TEMP_0_156 TEMP_1_156 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_157 (TEMP_0_157 TEMP_1_157 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_158 (TEMP_0_158 TEMP_1_158 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_159 (TEMP_0_159 TEMP_1_159 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_160 (TEMP_0_160 TEMP_1_160 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_161 (TEMP_0_161 TEMP_1_161 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_162 (TEMP_0_162 TEMP_1_162 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_163 (TEMP_0_163 TEMP_1_163 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_164 (TEMP_0_164 TEMP_1_164 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_165 (TEMP_0_165 TEMP_1_165 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_166 (TEMP_0_166 TEMP_1_166 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_167 (TEMP_0_167 TEMP_1_167 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_168 (TEMP_0_168 TEMP_1_168 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_169 (TEMP_0_169 TEMP_1_169 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_170 (TEMP_0_170 TEMP_1_170 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_171 (TEMP_0_171 TEMP_1_171 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_172 (TEMP_0_172 TEMP_1_172 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_173 (TEMP_0_173 TEMP_1_173 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_174 (TEMP_0_174 TEMP_1_174 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_175 (TEMP_0_175 TEMP_1_175 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_176 (TEMP_0_176 TEMP_1_176 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_177 (TEMP_0_177 TEMP_1_177 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_178 (TEMP_0_178 TEMP_1_178 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_179 (TEMP_0_179 TEMP_1_179 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_180 (TEMP_0_180 TEMP_1_180 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_181 (TEMP_0_181 TEMP_1_181 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_182 (TEMP_0_182 TEMP_1_182 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_183 (TEMP_0_183 TEMP_1_183 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_184 (TEMP_0_184 TEMP_1_184 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_185 (TEMP_0_185 TEMP_1_185 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_186 (TEMP_0_186 TEMP_1_186 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_187 (TEMP_0_187 TEMP_1_187 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_188 (TEMP_0_188 TEMP_1_188 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_189 (TEMP_0_189 TEMP_1_189 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_190 (TEMP_0_190 TEMP_1_190 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_191 (TEMP_0_191 TEMP_1_191 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_192 (TEMP_0_192 TEMP_1_192 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_193 (TEMP_0_193 TEMP_1_193 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_194 (TEMP_0_194 TEMP_1_194 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_195 (TEMP_0_195 TEMP_1_195 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_196 (TEMP_0_196 TEMP_1_196 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_197 (TEMP_0_197 TEMP_1_197 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_198 (TEMP_0_198 TEMP_1_198 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_199 (TEMP_0_199 TEMP_1_199 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_200 (TEMP_0_200 TEMP_1_200 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_201 (TEMP_0_201 TEMP_1_201 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_202 (TEMP_0_202 TEMP_1_202 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_203 (TEMP_0_203 TEMP_1_203 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_204 (TEMP_0_204 TEMP_1_204 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_205 (TEMP_0_205 TEMP_1_205 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_206 (TEMP_0_206 TEMP_1_206 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_207 (TEMP_0_207 TEMP_1_207 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_208 (TEMP_0_208 TEMP_1_208 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_209 (TEMP_0_209 TEMP_1_209 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_210 (TEMP_0_210 TEMP_1_210 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_211 (TEMP_0_211 TEMP_1_211 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_212 (TEMP_0_212 TEMP_1_212 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_213 (TEMP_0_213 TEMP_1_213 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_214 (TEMP_0_214 TEMP_1_214 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_215 (TEMP_0_215 TEMP_1_215 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_216 (TEMP_0_216 TEMP_1_216 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_217 (TEMP_0_217 TEMP_1_217 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_218 (TEMP_0_218 TEMP_1_218 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_219 (TEMP_0_219 TEMP_1_219 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_220 (TEMP_0_220 TEMP_1_220 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_221 (TEMP_0_221 TEMP_1_221 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_222 (TEMP_0_222 TEMP_1_222 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_223 (TEMP_0_223 TEMP_1_223 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_224 (TEMP_0_224 TEMP_1_224 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_225 (TEMP_0_225 TEMP_1_225 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_226 (TEMP_0_226 TEMP_1_226 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_227 (TEMP_0_227 TEMP_1_227 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_228 (TEMP_0_228 TEMP_1_228 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_229 (TEMP_0_229 TEMP_1_229 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_230 (TEMP_0_230 TEMP_1_230 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_231 (TEMP_0_231 TEMP_1_231 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_232 (TEMP_0_232 TEMP_1_232 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_233 (TEMP_0_233 TEMP_1_233 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_234 (TEMP_0_234 TEMP_1_234 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_235 (TEMP_0_235 TEMP_1_235 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_236 (TEMP_0_236 TEMP_1_236 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_237 (TEMP_0_237 TEMP_1_237 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_238 (TEMP_0_238 TEMP_1_238 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_239 (TEMP_0_239 TEMP_1_239 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_240 (TEMP_0_240 TEMP_1_240 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_241 (TEMP_0_241 TEMP_1_241 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_242 (TEMP_0_242 TEMP_1_242 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_243 (TEMP_0_243 TEMP_1_243 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_244 (TEMP_0_244 TEMP_1_244 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_245 (TEMP_0_245 TEMP_1_245 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_246 (TEMP_0_246 TEMP_1_246 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_247 (TEMP_0_247 TEMP_1_247 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_248 (TEMP_0_248 TEMP_1_248 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_249 (TEMP_0_249 TEMP_1_249 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_250 (TEMP_0_250 TEMP_1_250 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_251 (TEMP_0_251 TEMP_1_251 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_252 (TEMP_0_252 TEMP_1_252 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_253 (TEMP_0_253 TEMP_1_253 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_254 (TEMP_0_254 TEMP_1_254 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_0_255 (TEMP_0_255 TEMP_1_255 vdd vss PBulkLine NBulkLine) inverter mult=1
xNOT_1_0 (TEMP_1_0 TEMP_2_0 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_1 (TEMP_1_1 TEMP_2_1 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_2 (TEMP_1_2 TEMP_2_2 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_3 (TEMP_1_3 TEMP_2_3 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_4 (TEMP_1_4 TEMP_2_4 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_5 (TEMP_1_5 TEMP_2_5 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_6 (TEMP_1_6 TEMP_2_6 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_7 (TEMP_1_7 TEMP_2_7 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_8 (TEMP_1_8 TEMP_2_8 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_9 (TEMP_1_9 TEMP_2_9 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_10 (TEMP_1_10 TEMP_2_10 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_11 (TEMP_1_11 TEMP_2_11 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_12 (TEMP_1_12 TEMP_2_12 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_13 (TEMP_1_13 TEMP_2_13 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_14 (TEMP_1_14 TEMP_2_14 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_15 (TEMP_1_15 TEMP_2_15 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_16 (TEMP_1_16 TEMP_2_16 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_17 (TEMP_1_17 TEMP_2_17 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_18 (TEMP_1_18 TEMP_2_18 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_19 (TEMP_1_19 TEMP_2_19 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_20 (TEMP_1_20 TEMP_2_20 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_21 (TEMP_1_21 TEMP_2_21 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_22 (TEMP_1_22 TEMP_2_22 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_23 (TEMP_1_23 TEMP_2_23 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_24 (TEMP_1_24 TEMP_2_24 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_25 (TEMP_1_25 TEMP_2_25 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_26 (TEMP_1_26 TEMP_2_26 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_27 (TEMP_1_27 TEMP_2_27 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_28 (TEMP_1_28 TEMP_2_28 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_29 (TEMP_1_29 TEMP_2_29 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_30 (TEMP_1_30 TEMP_2_30 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_31 (TEMP_1_31 TEMP_2_31 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_32 (TEMP_1_32 TEMP_2_32 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_33 (TEMP_1_33 TEMP_2_33 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_34 (TEMP_1_34 TEMP_2_34 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_35 (TEMP_1_35 TEMP_2_35 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_36 (TEMP_1_36 TEMP_2_36 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_37 (TEMP_1_37 TEMP_2_37 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_38 (TEMP_1_38 TEMP_2_38 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_39 (TEMP_1_39 TEMP_2_39 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_40 (TEMP_1_40 TEMP_2_40 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_41 (TEMP_1_41 TEMP_2_41 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_42 (TEMP_1_42 TEMP_2_42 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_43 (TEMP_1_43 TEMP_2_43 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_44 (TEMP_1_44 TEMP_2_44 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_45 (TEMP_1_45 TEMP_2_45 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_46 (TEMP_1_46 TEMP_2_46 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_47 (TEMP_1_47 TEMP_2_47 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_48 (TEMP_1_48 TEMP_2_48 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_49 (TEMP_1_49 TEMP_2_49 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_50 (TEMP_1_50 TEMP_2_50 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_51 (TEMP_1_51 TEMP_2_51 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_52 (TEMP_1_52 TEMP_2_52 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_53 (TEMP_1_53 TEMP_2_53 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_54 (TEMP_1_54 TEMP_2_54 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_55 (TEMP_1_55 TEMP_2_55 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_56 (TEMP_1_56 TEMP_2_56 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_57 (TEMP_1_57 TEMP_2_57 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_58 (TEMP_1_58 TEMP_2_58 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_59 (TEMP_1_59 TEMP_2_59 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_60 (TEMP_1_60 TEMP_2_60 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_61 (TEMP_1_61 TEMP_2_61 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_62 (TEMP_1_62 TEMP_2_62 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_63 (TEMP_1_63 TEMP_2_63 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_64 (TEMP_1_64 TEMP_2_64 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_65 (TEMP_1_65 TEMP_2_65 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_66 (TEMP_1_66 TEMP_2_66 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_67 (TEMP_1_67 TEMP_2_67 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_68 (TEMP_1_68 TEMP_2_68 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_69 (TEMP_1_69 TEMP_2_69 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_70 (TEMP_1_70 TEMP_2_70 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_71 (TEMP_1_71 TEMP_2_71 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_72 (TEMP_1_72 TEMP_2_72 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_73 (TEMP_1_73 TEMP_2_73 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_74 (TEMP_1_74 TEMP_2_74 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_75 (TEMP_1_75 TEMP_2_75 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_76 (TEMP_1_76 TEMP_2_76 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_77 (TEMP_1_77 TEMP_2_77 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_78 (TEMP_1_78 TEMP_2_78 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_79 (TEMP_1_79 TEMP_2_79 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_80 (TEMP_1_80 TEMP_2_80 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_81 (TEMP_1_81 TEMP_2_81 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_82 (TEMP_1_82 TEMP_2_82 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_83 (TEMP_1_83 TEMP_2_83 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_84 (TEMP_1_84 TEMP_2_84 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_85 (TEMP_1_85 TEMP_2_85 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_86 (TEMP_1_86 TEMP_2_86 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_87 (TEMP_1_87 TEMP_2_87 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_88 (TEMP_1_88 TEMP_2_88 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_89 (TEMP_1_89 TEMP_2_89 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_90 (TEMP_1_90 TEMP_2_90 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_91 (TEMP_1_91 TEMP_2_91 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_92 (TEMP_1_92 TEMP_2_92 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_93 (TEMP_1_93 TEMP_2_93 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_94 (TEMP_1_94 TEMP_2_94 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_95 (TEMP_1_95 TEMP_2_95 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_96 (TEMP_1_96 TEMP_2_96 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_97 (TEMP_1_97 TEMP_2_97 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_98 (TEMP_1_98 TEMP_2_98 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_99 (TEMP_1_99 TEMP_2_99 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_100 (TEMP_1_100 TEMP_2_100 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_101 (TEMP_1_101 TEMP_2_101 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_102 (TEMP_1_102 TEMP_2_102 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_103 (TEMP_1_103 TEMP_2_103 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_104 (TEMP_1_104 TEMP_2_104 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_105 (TEMP_1_105 TEMP_2_105 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_106 (TEMP_1_106 TEMP_2_106 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_107 (TEMP_1_107 TEMP_2_107 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_108 (TEMP_1_108 TEMP_2_108 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_109 (TEMP_1_109 TEMP_2_109 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_110 (TEMP_1_110 TEMP_2_110 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_111 (TEMP_1_111 TEMP_2_111 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_112 (TEMP_1_112 TEMP_2_112 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_113 (TEMP_1_113 TEMP_2_113 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_114 (TEMP_1_114 TEMP_2_114 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_115 (TEMP_1_115 TEMP_2_115 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_116 (TEMP_1_116 TEMP_2_116 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_117 (TEMP_1_117 TEMP_2_117 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_118 (TEMP_1_118 TEMP_2_118 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_119 (TEMP_1_119 TEMP_2_119 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_120 (TEMP_1_120 TEMP_2_120 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_121 (TEMP_1_121 TEMP_2_121 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_122 (TEMP_1_122 TEMP_2_122 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_123 (TEMP_1_123 TEMP_2_123 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_124 (TEMP_1_124 TEMP_2_124 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_125 (TEMP_1_125 TEMP_2_125 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_126 (TEMP_1_126 TEMP_2_126 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_127 (TEMP_1_127 TEMP_2_127 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_128 (TEMP_1_128 TEMP_2_128 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_129 (TEMP_1_129 TEMP_2_129 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_130 (TEMP_1_130 TEMP_2_130 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_131 (TEMP_1_131 TEMP_2_131 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_132 (TEMP_1_132 TEMP_2_132 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_133 (TEMP_1_133 TEMP_2_133 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_134 (TEMP_1_134 TEMP_2_134 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_135 (TEMP_1_135 TEMP_2_135 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_136 (TEMP_1_136 TEMP_2_136 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_137 (TEMP_1_137 TEMP_2_137 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_138 (TEMP_1_138 TEMP_2_138 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_139 (TEMP_1_139 TEMP_2_139 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_140 (TEMP_1_140 TEMP_2_140 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_141 (TEMP_1_141 TEMP_2_141 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_142 (TEMP_1_142 TEMP_2_142 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_143 (TEMP_1_143 TEMP_2_143 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_144 (TEMP_1_144 TEMP_2_144 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_145 (TEMP_1_145 TEMP_2_145 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_146 (TEMP_1_146 TEMP_2_146 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_147 (TEMP_1_147 TEMP_2_147 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_148 (TEMP_1_148 TEMP_2_148 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_149 (TEMP_1_149 TEMP_2_149 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_150 (TEMP_1_150 TEMP_2_150 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_151 (TEMP_1_151 TEMP_2_151 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_152 (TEMP_1_152 TEMP_2_152 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_153 (TEMP_1_153 TEMP_2_153 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_154 (TEMP_1_154 TEMP_2_154 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_155 (TEMP_1_155 TEMP_2_155 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_156 (TEMP_1_156 TEMP_2_156 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_157 (TEMP_1_157 TEMP_2_157 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_158 (TEMP_1_158 TEMP_2_158 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_159 (TEMP_1_159 TEMP_2_159 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_160 (TEMP_1_160 TEMP_2_160 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_161 (TEMP_1_161 TEMP_2_161 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_162 (TEMP_1_162 TEMP_2_162 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_163 (TEMP_1_163 TEMP_2_163 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_164 (TEMP_1_164 TEMP_2_164 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_165 (TEMP_1_165 TEMP_2_165 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_166 (TEMP_1_166 TEMP_2_166 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_167 (TEMP_1_167 TEMP_2_167 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_168 (TEMP_1_168 TEMP_2_168 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_169 (TEMP_1_169 TEMP_2_169 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_170 (TEMP_1_170 TEMP_2_170 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_171 (TEMP_1_171 TEMP_2_171 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_172 (TEMP_1_172 TEMP_2_172 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_173 (TEMP_1_173 TEMP_2_173 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_174 (TEMP_1_174 TEMP_2_174 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_175 (TEMP_1_175 TEMP_2_175 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_176 (TEMP_1_176 TEMP_2_176 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_177 (TEMP_1_177 TEMP_2_177 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_178 (TEMP_1_178 TEMP_2_178 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_179 (TEMP_1_179 TEMP_2_179 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_180 (TEMP_1_180 TEMP_2_180 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_181 (TEMP_1_181 TEMP_2_181 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_182 (TEMP_1_182 TEMP_2_182 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_183 (TEMP_1_183 TEMP_2_183 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_184 (TEMP_1_184 TEMP_2_184 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_185 (TEMP_1_185 TEMP_2_185 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_186 (TEMP_1_186 TEMP_2_186 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_187 (TEMP_1_187 TEMP_2_187 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_188 (TEMP_1_188 TEMP_2_188 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_189 (TEMP_1_189 TEMP_2_189 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_190 (TEMP_1_190 TEMP_2_190 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_191 (TEMP_1_191 TEMP_2_191 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_192 (TEMP_1_192 TEMP_2_192 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_193 (TEMP_1_193 TEMP_2_193 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_194 (TEMP_1_194 TEMP_2_194 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_195 (TEMP_1_195 TEMP_2_195 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_196 (TEMP_1_196 TEMP_2_196 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_197 (TEMP_1_197 TEMP_2_197 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_198 (TEMP_1_198 TEMP_2_198 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_199 (TEMP_1_199 TEMP_2_199 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_200 (TEMP_1_200 TEMP_2_200 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_201 (TEMP_1_201 TEMP_2_201 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_202 (TEMP_1_202 TEMP_2_202 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_203 (TEMP_1_203 TEMP_2_203 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_204 (TEMP_1_204 TEMP_2_204 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_205 (TEMP_1_205 TEMP_2_205 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_206 (TEMP_1_206 TEMP_2_206 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_207 (TEMP_1_207 TEMP_2_207 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_208 (TEMP_1_208 TEMP_2_208 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_209 (TEMP_1_209 TEMP_2_209 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_210 (TEMP_1_210 TEMP_2_210 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_211 (TEMP_1_211 TEMP_2_211 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_212 (TEMP_1_212 TEMP_2_212 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_213 (TEMP_1_213 TEMP_2_213 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_214 (TEMP_1_214 TEMP_2_214 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_215 (TEMP_1_215 TEMP_2_215 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_216 (TEMP_1_216 TEMP_2_216 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_217 (TEMP_1_217 TEMP_2_217 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_218 (TEMP_1_218 TEMP_2_218 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_219 (TEMP_1_219 TEMP_2_219 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_220 (TEMP_1_220 TEMP_2_220 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_221 (TEMP_1_221 TEMP_2_221 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_222 (TEMP_1_222 TEMP_2_222 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_223 (TEMP_1_223 TEMP_2_223 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_224 (TEMP_1_224 TEMP_2_224 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_225 (TEMP_1_225 TEMP_2_225 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_226 (TEMP_1_226 TEMP_2_226 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_227 (TEMP_1_227 TEMP_2_227 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_228 (TEMP_1_228 TEMP_2_228 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_229 (TEMP_1_229 TEMP_2_229 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_230 (TEMP_1_230 TEMP_2_230 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_231 (TEMP_1_231 TEMP_2_231 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_232 (TEMP_1_232 TEMP_2_232 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_233 (TEMP_1_233 TEMP_2_233 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_234 (TEMP_1_234 TEMP_2_234 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_235 (TEMP_1_235 TEMP_2_235 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_236 (TEMP_1_236 TEMP_2_236 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_237 (TEMP_1_237 TEMP_2_237 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_238 (TEMP_1_238 TEMP_2_238 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_239 (TEMP_1_239 TEMP_2_239 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_240 (TEMP_1_240 TEMP_2_240 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_241 (TEMP_1_241 TEMP_2_241 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_242 (TEMP_1_242 TEMP_2_242 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_243 (TEMP_1_243 TEMP_2_243 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_244 (TEMP_1_244 TEMP_2_244 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_245 (TEMP_1_245 TEMP_2_245 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_246 (TEMP_1_246 TEMP_2_246 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_247 (TEMP_1_247 TEMP_2_247 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_248 (TEMP_1_248 TEMP_2_248 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_249 (TEMP_1_249 TEMP_2_249 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_250 (TEMP_1_250 TEMP_2_250 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_251 (TEMP_1_251 TEMP_2_251 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_252 (TEMP_1_252 TEMP_2_252 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_253 (TEMP_1_253 TEMP_2_253 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_254 (TEMP_1_254 TEMP_2_254 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_1_255 (TEMP_1_255 TEMP_2_255 vdd vss PBulkLine NBulkLine) inverter mult=1.0282856
xNOT_2_0 (TEMP_2_0 TEMP_3_0 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_1 (TEMP_2_1 TEMP_3_1 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_2 (TEMP_2_2 TEMP_3_2 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_3 (TEMP_2_3 TEMP_3_3 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_4 (TEMP_2_4 TEMP_3_4 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_5 (TEMP_2_5 TEMP_3_5 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_6 (TEMP_2_6 TEMP_3_6 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_7 (TEMP_2_7 TEMP_3_7 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_8 (TEMP_2_8 TEMP_3_8 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_9 (TEMP_2_9 TEMP_3_9 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_10 (TEMP_2_10 TEMP_3_10 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_11 (TEMP_2_11 TEMP_3_11 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_12 (TEMP_2_12 TEMP_3_12 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_13 (TEMP_2_13 TEMP_3_13 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_14 (TEMP_2_14 TEMP_3_14 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_15 (TEMP_2_15 TEMP_3_15 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_16 (TEMP_2_16 TEMP_3_16 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_17 (TEMP_2_17 TEMP_3_17 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_18 (TEMP_2_18 TEMP_3_18 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_19 (TEMP_2_19 TEMP_3_19 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_20 (TEMP_2_20 TEMP_3_20 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_21 (TEMP_2_21 TEMP_3_21 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_22 (TEMP_2_22 TEMP_3_22 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_23 (TEMP_2_23 TEMP_3_23 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_24 (TEMP_2_24 TEMP_3_24 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_25 (TEMP_2_25 TEMP_3_25 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_26 (TEMP_2_26 TEMP_3_26 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_27 (TEMP_2_27 TEMP_3_27 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_28 (TEMP_2_28 TEMP_3_28 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_29 (TEMP_2_29 TEMP_3_29 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_30 (TEMP_2_30 TEMP_3_30 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_31 (TEMP_2_31 TEMP_3_31 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_32 (TEMP_2_32 TEMP_3_32 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_33 (TEMP_2_33 TEMP_3_33 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_34 (TEMP_2_34 TEMP_3_34 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_35 (TEMP_2_35 TEMP_3_35 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_36 (TEMP_2_36 TEMP_3_36 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_37 (TEMP_2_37 TEMP_3_37 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_38 (TEMP_2_38 TEMP_3_38 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_39 (TEMP_2_39 TEMP_3_39 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_40 (TEMP_2_40 TEMP_3_40 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_41 (TEMP_2_41 TEMP_3_41 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_42 (TEMP_2_42 TEMP_3_42 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_43 (TEMP_2_43 TEMP_3_43 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_44 (TEMP_2_44 TEMP_3_44 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_45 (TEMP_2_45 TEMP_3_45 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_46 (TEMP_2_46 TEMP_3_46 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_47 (TEMP_2_47 TEMP_3_47 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_48 (TEMP_2_48 TEMP_3_48 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_49 (TEMP_2_49 TEMP_3_49 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_50 (TEMP_2_50 TEMP_3_50 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_51 (TEMP_2_51 TEMP_3_51 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_52 (TEMP_2_52 TEMP_3_52 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_53 (TEMP_2_53 TEMP_3_53 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_54 (TEMP_2_54 TEMP_3_54 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_55 (TEMP_2_55 TEMP_3_55 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_56 (TEMP_2_56 TEMP_3_56 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_57 (TEMP_2_57 TEMP_3_57 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_58 (TEMP_2_58 TEMP_3_58 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_59 (TEMP_2_59 TEMP_3_59 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_60 (TEMP_2_60 TEMP_3_60 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_61 (TEMP_2_61 TEMP_3_61 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_62 (TEMP_2_62 TEMP_3_62 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_63 (TEMP_2_63 TEMP_3_63 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_64 (TEMP_2_64 TEMP_3_64 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_65 (TEMP_2_65 TEMP_3_65 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_66 (TEMP_2_66 TEMP_3_66 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_67 (TEMP_2_67 TEMP_3_67 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_68 (TEMP_2_68 TEMP_3_68 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_69 (TEMP_2_69 TEMP_3_69 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_70 (TEMP_2_70 TEMP_3_70 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_71 (TEMP_2_71 TEMP_3_71 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_72 (TEMP_2_72 TEMP_3_72 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_73 (TEMP_2_73 TEMP_3_73 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_74 (TEMP_2_74 TEMP_3_74 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_75 (TEMP_2_75 TEMP_3_75 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_76 (TEMP_2_76 TEMP_3_76 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_77 (TEMP_2_77 TEMP_3_77 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_78 (TEMP_2_78 TEMP_3_78 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_79 (TEMP_2_79 TEMP_3_79 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_80 (TEMP_2_80 TEMP_3_80 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_81 (TEMP_2_81 TEMP_3_81 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_82 (TEMP_2_82 TEMP_3_82 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_83 (TEMP_2_83 TEMP_3_83 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_84 (TEMP_2_84 TEMP_3_84 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_85 (TEMP_2_85 TEMP_3_85 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_86 (TEMP_2_86 TEMP_3_86 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_87 (TEMP_2_87 TEMP_3_87 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_88 (TEMP_2_88 TEMP_3_88 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_89 (TEMP_2_89 TEMP_3_89 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_90 (TEMP_2_90 TEMP_3_90 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_91 (TEMP_2_91 TEMP_3_91 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_92 (TEMP_2_92 TEMP_3_92 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_93 (TEMP_2_93 TEMP_3_93 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_94 (TEMP_2_94 TEMP_3_94 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_95 (TEMP_2_95 TEMP_3_95 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_96 (TEMP_2_96 TEMP_3_96 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_97 (TEMP_2_97 TEMP_3_97 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_98 (TEMP_2_98 TEMP_3_98 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_99 (TEMP_2_99 TEMP_3_99 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_100 (TEMP_2_100 TEMP_3_100 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_101 (TEMP_2_101 TEMP_3_101 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_102 (TEMP_2_102 TEMP_3_102 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_103 (TEMP_2_103 TEMP_3_103 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_104 (TEMP_2_104 TEMP_3_104 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_105 (TEMP_2_105 TEMP_3_105 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_106 (TEMP_2_106 TEMP_3_106 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_107 (TEMP_2_107 TEMP_3_107 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_108 (TEMP_2_108 TEMP_3_108 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_109 (TEMP_2_109 TEMP_3_109 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_110 (TEMP_2_110 TEMP_3_110 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_111 (TEMP_2_111 TEMP_3_111 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_112 (TEMP_2_112 TEMP_3_112 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_113 (TEMP_2_113 TEMP_3_113 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_114 (TEMP_2_114 TEMP_3_114 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_115 (TEMP_2_115 TEMP_3_115 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_116 (TEMP_2_116 TEMP_3_116 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_117 (TEMP_2_117 TEMP_3_117 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_118 (TEMP_2_118 TEMP_3_118 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_119 (TEMP_2_119 TEMP_3_119 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_120 (TEMP_2_120 TEMP_3_120 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_121 (TEMP_2_121 TEMP_3_121 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_122 (TEMP_2_122 TEMP_3_122 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_123 (TEMP_2_123 TEMP_3_123 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_124 (TEMP_2_124 TEMP_3_124 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_125 (TEMP_2_125 TEMP_3_125 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_126 (TEMP_2_126 TEMP_3_126 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_127 (TEMP_2_127 TEMP_3_127 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_128 (TEMP_2_128 TEMP_3_128 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_129 (TEMP_2_129 TEMP_3_129 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_130 (TEMP_2_130 TEMP_3_130 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_131 (TEMP_2_131 TEMP_3_131 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_132 (TEMP_2_132 TEMP_3_132 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_133 (TEMP_2_133 TEMP_3_133 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_134 (TEMP_2_134 TEMP_3_134 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_135 (TEMP_2_135 TEMP_3_135 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_136 (TEMP_2_136 TEMP_3_136 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_137 (TEMP_2_137 TEMP_3_137 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_138 (TEMP_2_138 TEMP_3_138 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_139 (TEMP_2_139 TEMP_3_139 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_140 (TEMP_2_140 TEMP_3_140 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_141 (TEMP_2_141 TEMP_3_141 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_142 (TEMP_2_142 TEMP_3_142 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_143 (TEMP_2_143 TEMP_3_143 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_144 (TEMP_2_144 TEMP_3_144 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_145 (TEMP_2_145 TEMP_3_145 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_146 (TEMP_2_146 TEMP_3_146 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_147 (TEMP_2_147 TEMP_3_147 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_148 (TEMP_2_148 TEMP_3_148 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_149 (TEMP_2_149 TEMP_3_149 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_150 (TEMP_2_150 TEMP_3_150 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_151 (TEMP_2_151 TEMP_3_151 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_152 (TEMP_2_152 TEMP_3_152 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_153 (TEMP_2_153 TEMP_3_153 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_154 (TEMP_2_154 TEMP_3_154 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_155 (TEMP_2_155 TEMP_3_155 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_156 (TEMP_2_156 TEMP_3_156 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_157 (TEMP_2_157 TEMP_3_157 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_158 (TEMP_2_158 TEMP_3_158 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_159 (TEMP_2_159 TEMP_3_159 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_160 (TEMP_2_160 TEMP_3_160 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_161 (TEMP_2_161 TEMP_3_161 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_162 (TEMP_2_162 TEMP_3_162 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_163 (TEMP_2_163 TEMP_3_163 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_164 (TEMP_2_164 TEMP_3_164 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_165 (TEMP_2_165 TEMP_3_165 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_166 (TEMP_2_166 TEMP_3_166 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_167 (TEMP_2_167 TEMP_3_167 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_168 (TEMP_2_168 TEMP_3_168 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_169 (TEMP_2_169 TEMP_3_169 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_170 (TEMP_2_170 TEMP_3_170 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_171 (TEMP_2_171 TEMP_3_171 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_172 (TEMP_2_172 TEMP_3_172 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_173 (TEMP_2_173 TEMP_3_173 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_174 (TEMP_2_174 TEMP_3_174 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_175 (TEMP_2_175 TEMP_3_175 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_176 (TEMP_2_176 TEMP_3_176 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_177 (TEMP_2_177 TEMP_3_177 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_178 (TEMP_2_178 TEMP_3_178 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_179 (TEMP_2_179 TEMP_3_179 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_180 (TEMP_2_180 TEMP_3_180 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_181 (TEMP_2_181 TEMP_3_181 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_182 (TEMP_2_182 TEMP_3_182 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_183 (TEMP_2_183 TEMP_3_183 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_184 (TEMP_2_184 TEMP_3_184 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_185 (TEMP_2_185 TEMP_3_185 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_186 (TEMP_2_186 TEMP_3_186 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_187 (TEMP_2_187 TEMP_3_187 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_188 (TEMP_2_188 TEMP_3_188 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_189 (TEMP_2_189 TEMP_3_189 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_190 (TEMP_2_190 TEMP_3_190 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_191 (TEMP_2_191 TEMP_3_191 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_192 (TEMP_2_192 TEMP_3_192 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_193 (TEMP_2_193 TEMP_3_193 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_194 (TEMP_2_194 TEMP_3_194 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_195 (TEMP_2_195 TEMP_3_195 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_196 (TEMP_2_196 TEMP_3_196 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_197 (TEMP_2_197 TEMP_3_197 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_198 (TEMP_2_198 TEMP_3_198 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_199 (TEMP_2_199 TEMP_3_199 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_200 (TEMP_2_200 TEMP_3_200 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_201 (TEMP_2_201 TEMP_3_201 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_202 (TEMP_2_202 TEMP_3_202 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_203 (TEMP_2_203 TEMP_3_203 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_204 (TEMP_2_204 TEMP_3_204 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_205 (TEMP_2_205 TEMP_3_205 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_206 (TEMP_2_206 TEMP_3_206 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_207 (TEMP_2_207 TEMP_3_207 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_208 (TEMP_2_208 TEMP_3_208 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_209 (TEMP_2_209 TEMP_3_209 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_210 (TEMP_2_210 TEMP_3_210 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_211 (TEMP_2_211 TEMP_3_211 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_212 (TEMP_2_212 TEMP_3_212 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_213 (TEMP_2_213 TEMP_3_213 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_214 (TEMP_2_214 TEMP_3_214 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_215 (TEMP_2_215 TEMP_3_215 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_216 (TEMP_2_216 TEMP_3_216 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_217 (TEMP_2_217 TEMP_3_217 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_218 (TEMP_2_218 TEMP_3_218 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_219 (TEMP_2_219 TEMP_3_219 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_220 (TEMP_2_220 TEMP_3_220 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_221 (TEMP_2_221 TEMP_3_221 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_222 (TEMP_2_222 TEMP_3_222 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_223 (TEMP_2_223 TEMP_3_223 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_224 (TEMP_2_224 TEMP_3_224 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_225 (TEMP_2_225 TEMP_3_225 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_226 (TEMP_2_226 TEMP_3_226 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_227 (TEMP_2_227 TEMP_3_227 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_228 (TEMP_2_228 TEMP_3_228 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_229 (TEMP_2_229 TEMP_3_229 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_230 (TEMP_2_230 TEMP_3_230 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_231 (TEMP_2_231 TEMP_3_231 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_232 (TEMP_2_232 TEMP_3_232 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_233 (TEMP_2_233 TEMP_3_233 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_234 (TEMP_2_234 TEMP_3_234 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_235 (TEMP_2_235 TEMP_3_235 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_236 (TEMP_2_236 TEMP_3_236 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_237 (TEMP_2_237 TEMP_3_237 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_238 (TEMP_2_238 TEMP_3_238 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_239 (TEMP_2_239 TEMP_3_239 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_240 (TEMP_2_240 TEMP_3_240 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_241 (TEMP_2_241 TEMP_3_241 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_242 (TEMP_2_242 TEMP_3_242 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_243 (TEMP_2_243 TEMP_3_243 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_244 (TEMP_2_244 TEMP_3_244 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_245 (TEMP_2_245 TEMP_3_245 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_246 (TEMP_2_246 TEMP_3_246 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_247 (TEMP_2_247 TEMP_3_247 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_248 (TEMP_2_248 TEMP_3_248 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_249 (TEMP_2_249 TEMP_3_249 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_250 (TEMP_2_250 TEMP_3_250 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_251 (TEMP_2_251 TEMP_3_251 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_252 (TEMP_2_252 TEMP_3_252 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_253 (TEMP_2_253 TEMP_3_253 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_254 (TEMP_2_254 TEMP_3_254 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_2_255 (TEMP_2_255 TEMP_3_255 vdd vss PBulkLine NBulkLine) inverter mult=1.0573713
xNOT_3_0 (TEMP_3_0 TEMP_4_0 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_1 (TEMP_3_1 TEMP_4_1 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_2 (TEMP_3_2 TEMP_4_2 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_3 (TEMP_3_3 TEMP_4_3 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_4 (TEMP_3_4 TEMP_4_4 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_5 (TEMP_3_5 TEMP_4_5 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_6 (TEMP_3_6 TEMP_4_6 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_7 (TEMP_3_7 TEMP_4_7 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_8 (TEMP_3_8 TEMP_4_8 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_9 (TEMP_3_9 TEMP_4_9 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_10 (TEMP_3_10 TEMP_4_10 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_11 (TEMP_3_11 TEMP_4_11 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_12 (TEMP_3_12 TEMP_4_12 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_13 (TEMP_3_13 TEMP_4_13 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_14 (TEMP_3_14 TEMP_4_14 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_15 (TEMP_3_15 TEMP_4_15 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_16 (TEMP_3_16 TEMP_4_16 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_17 (TEMP_3_17 TEMP_4_17 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_18 (TEMP_3_18 TEMP_4_18 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_19 (TEMP_3_19 TEMP_4_19 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_20 (TEMP_3_20 TEMP_4_20 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_21 (TEMP_3_21 TEMP_4_21 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_22 (TEMP_3_22 TEMP_4_22 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_23 (TEMP_3_23 TEMP_4_23 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_24 (TEMP_3_24 TEMP_4_24 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_25 (TEMP_3_25 TEMP_4_25 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_26 (TEMP_3_26 TEMP_4_26 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_27 (TEMP_3_27 TEMP_4_27 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_28 (TEMP_3_28 TEMP_4_28 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_29 (TEMP_3_29 TEMP_4_29 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_30 (TEMP_3_30 TEMP_4_30 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_31 (TEMP_3_31 TEMP_4_31 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_32 (TEMP_3_32 TEMP_4_32 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_33 (TEMP_3_33 TEMP_4_33 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_34 (TEMP_3_34 TEMP_4_34 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_35 (TEMP_3_35 TEMP_4_35 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_36 (TEMP_3_36 TEMP_4_36 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_37 (TEMP_3_37 TEMP_4_37 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_38 (TEMP_3_38 TEMP_4_38 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_39 (TEMP_3_39 TEMP_4_39 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_40 (TEMP_3_40 TEMP_4_40 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_41 (TEMP_3_41 TEMP_4_41 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_42 (TEMP_3_42 TEMP_4_42 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_43 (TEMP_3_43 TEMP_4_43 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_44 (TEMP_3_44 TEMP_4_44 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_45 (TEMP_3_45 TEMP_4_45 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_46 (TEMP_3_46 TEMP_4_46 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_47 (TEMP_3_47 TEMP_4_47 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_48 (TEMP_3_48 TEMP_4_48 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_49 (TEMP_3_49 TEMP_4_49 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_50 (TEMP_3_50 TEMP_4_50 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_51 (TEMP_3_51 TEMP_4_51 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_52 (TEMP_3_52 TEMP_4_52 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_53 (TEMP_3_53 TEMP_4_53 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_54 (TEMP_3_54 TEMP_4_54 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_55 (TEMP_3_55 TEMP_4_55 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_56 (TEMP_3_56 TEMP_4_56 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_57 (TEMP_3_57 TEMP_4_57 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_58 (TEMP_3_58 TEMP_4_58 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_59 (TEMP_3_59 TEMP_4_59 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_60 (TEMP_3_60 TEMP_4_60 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_61 (TEMP_3_61 TEMP_4_61 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_62 (TEMP_3_62 TEMP_4_62 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_63 (TEMP_3_63 TEMP_4_63 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_64 (TEMP_3_64 TEMP_4_64 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_65 (TEMP_3_65 TEMP_4_65 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_66 (TEMP_3_66 TEMP_4_66 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_67 (TEMP_3_67 TEMP_4_67 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_68 (TEMP_3_68 TEMP_4_68 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_69 (TEMP_3_69 TEMP_4_69 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_70 (TEMP_3_70 TEMP_4_70 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_71 (TEMP_3_71 TEMP_4_71 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_72 (TEMP_3_72 TEMP_4_72 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_73 (TEMP_3_73 TEMP_4_73 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_74 (TEMP_3_74 TEMP_4_74 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_75 (TEMP_3_75 TEMP_4_75 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_76 (TEMP_3_76 TEMP_4_76 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_77 (TEMP_3_77 TEMP_4_77 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_78 (TEMP_3_78 TEMP_4_78 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_79 (TEMP_3_79 TEMP_4_79 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_80 (TEMP_3_80 TEMP_4_80 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_81 (TEMP_3_81 TEMP_4_81 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_82 (TEMP_3_82 TEMP_4_82 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_83 (TEMP_3_83 TEMP_4_83 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_84 (TEMP_3_84 TEMP_4_84 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_85 (TEMP_3_85 TEMP_4_85 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_86 (TEMP_3_86 TEMP_4_86 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_87 (TEMP_3_87 TEMP_4_87 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_88 (TEMP_3_88 TEMP_4_88 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_89 (TEMP_3_89 TEMP_4_89 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_90 (TEMP_3_90 TEMP_4_90 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_91 (TEMP_3_91 TEMP_4_91 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_92 (TEMP_3_92 TEMP_4_92 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_93 (TEMP_3_93 TEMP_4_93 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_94 (TEMP_3_94 TEMP_4_94 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_95 (TEMP_3_95 TEMP_4_95 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_96 (TEMP_3_96 TEMP_4_96 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_97 (TEMP_3_97 TEMP_4_97 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_98 (TEMP_3_98 TEMP_4_98 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_99 (TEMP_3_99 TEMP_4_99 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_100 (TEMP_3_100 TEMP_4_100 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_101 (TEMP_3_101 TEMP_4_101 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_102 (TEMP_3_102 TEMP_4_102 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_103 (TEMP_3_103 TEMP_4_103 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_104 (TEMP_3_104 TEMP_4_104 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_105 (TEMP_3_105 TEMP_4_105 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_106 (TEMP_3_106 TEMP_4_106 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_107 (TEMP_3_107 TEMP_4_107 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_108 (TEMP_3_108 TEMP_4_108 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_109 (TEMP_3_109 TEMP_4_109 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_110 (TEMP_3_110 TEMP_4_110 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_111 (TEMP_3_111 TEMP_4_111 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_112 (TEMP_3_112 TEMP_4_112 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_113 (TEMP_3_113 TEMP_4_113 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_114 (TEMP_3_114 TEMP_4_114 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_115 (TEMP_3_115 TEMP_4_115 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_116 (TEMP_3_116 TEMP_4_116 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_117 (TEMP_3_117 TEMP_4_117 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_118 (TEMP_3_118 TEMP_4_118 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_119 (TEMP_3_119 TEMP_4_119 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_120 (TEMP_3_120 TEMP_4_120 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_121 (TEMP_3_121 TEMP_4_121 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_122 (TEMP_3_122 TEMP_4_122 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_123 (TEMP_3_123 TEMP_4_123 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_124 (TEMP_3_124 TEMP_4_124 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_125 (TEMP_3_125 TEMP_4_125 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_126 (TEMP_3_126 TEMP_4_126 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_127 (TEMP_3_127 TEMP_4_127 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_128 (TEMP_3_128 TEMP_4_128 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_129 (TEMP_3_129 TEMP_4_129 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_130 (TEMP_3_130 TEMP_4_130 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_131 (TEMP_3_131 TEMP_4_131 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_132 (TEMP_3_132 TEMP_4_132 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_133 (TEMP_3_133 TEMP_4_133 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_134 (TEMP_3_134 TEMP_4_134 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_135 (TEMP_3_135 TEMP_4_135 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_136 (TEMP_3_136 TEMP_4_136 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_137 (TEMP_3_137 TEMP_4_137 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_138 (TEMP_3_138 TEMP_4_138 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_139 (TEMP_3_139 TEMP_4_139 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_140 (TEMP_3_140 TEMP_4_140 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_141 (TEMP_3_141 TEMP_4_141 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_142 (TEMP_3_142 TEMP_4_142 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_143 (TEMP_3_143 TEMP_4_143 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_144 (TEMP_3_144 TEMP_4_144 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_145 (TEMP_3_145 TEMP_4_145 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_146 (TEMP_3_146 TEMP_4_146 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_147 (TEMP_3_147 TEMP_4_147 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_148 (TEMP_3_148 TEMP_4_148 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_149 (TEMP_3_149 TEMP_4_149 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_150 (TEMP_3_150 TEMP_4_150 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_151 (TEMP_3_151 TEMP_4_151 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_152 (TEMP_3_152 TEMP_4_152 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_153 (TEMP_3_153 TEMP_4_153 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_154 (TEMP_3_154 TEMP_4_154 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_155 (TEMP_3_155 TEMP_4_155 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_156 (TEMP_3_156 TEMP_4_156 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_157 (TEMP_3_157 TEMP_4_157 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_158 (TEMP_3_158 TEMP_4_158 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_159 (TEMP_3_159 TEMP_4_159 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_160 (TEMP_3_160 TEMP_4_160 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_161 (TEMP_3_161 TEMP_4_161 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_162 (TEMP_3_162 TEMP_4_162 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_163 (TEMP_3_163 TEMP_4_163 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_164 (TEMP_3_164 TEMP_4_164 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_165 (TEMP_3_165 TEMP_4_165 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_166 (TEMP_3_166 TEMP_4_166 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_167 (TEMP_3_167 TEMP_4_167 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_168 (TEMP_3_168 TEMP_4_168 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_169 (TEMP_3_169 TEMP_4_169 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_170 (TEMP_3_170 TEMP_4_170 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_171 (TEMP_3_171 TEMP_4_171 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_172 (TEMP_3_172 TEMP_4_172 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_173 (TEMP_3_173 TEMP_4_173 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_174 (TEMP_3_174 TEMP_4_174 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_175 (TEMP_3_175 TEMP_4_175 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_176 (TEMP_3_176 TEMP_4_176 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_177 (TEMP_3_177 TEMP_4_177 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_178 (TEMP_3_178 TEMP_4_178 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_179 (TEMP_3_179 TEMP_4_179 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_180 (TEMP_3_180 TEMP_4_180 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_181 (TEMP_3_181 TEMP_4_181 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_182 (TEMP_3_182 TEMP_4_182 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_183 (TEMP_3_183 TEMP_4_183 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_184 (TEMP_3_184 TEMP_4_184 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_185 (TEMP_3_185 TEMP_4_185 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_186 (TEMP_3_186 TEMP_4_186 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_187 (TEMP_3_187 TEMP_4_187 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_188 (TEMP_3_188 TEMP_4_188 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_189 (TEMP_3_189 TEMP_4_189 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_190 (TEMP_3_190 TEMP_4_190 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_191 (TEMP_3_191 TEMP_4_191 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_192 (TEMP_3_192 TEMP_4_192 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_193 (TEMP_3_193 TEMP_4_193 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_194 (TEMP_3_194 TEMP_4_194 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_195 (TEMP_3_195 TEMP_4_195 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_196 (TEMP_3_196 TEMP_4_196 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_197 (TEMP_3_197 TEMP_4_197 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_198 (TEMP_3_198 TEMP_4_198 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_199 (TEMP_3_199 TEMP_4_199 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_200 (TEMP_3_200 TEMP_4_200 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_201 (TEMP_3_201 TEMP_4_201 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_202 (TEMP_3_202 TEMP_4_202 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_203 (TEMP_3_203 TEMP_4_203 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_204 (TEMP_3_204 TEMP_4_204 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_205 (TEMP_3_205 TEMP_4_205 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_206 (TEMP_3_206 TEMP_4_206 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_207 (TEMP_3_207 TEMP_4_207 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_208 (TEMP_3_208 TEMP_4_208 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_209 (TEMP_3_209 TEMP_4_209 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_210 (TEMP_3_210 TEMP_4_210 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_211 (TEMP_3_211 TEMP_4_211 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_212 (TEMP_3_212 TEMP_4_212 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_213 (TEMP_3_213 TEMP_4_213 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_214 (TEMP_3_214 TEMP_4_214 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_215 (TEMP_3_215 TEMP_4_215 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_216 (TEMP_3_216 TEMP_4_216 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_217 (TEMP_3_217 TEMP_4_217 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_218 (TEMP_3_218 TEMP_4_218 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_219 (TEMP_3_219 TEMP_4_219 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_220 (TEMP_3_220 TEMP_4_220 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_221 (TEMP_3_221 TEMP_4_221 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_222 (TEMP_3_222 TEMP_4_222 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_223 (TEMP_3_223 TEMP_4_223 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_224 (TEMP_3_224 TEMP_4_224 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_225 (TEMP_3_225 TEMP_4_225 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_226 (TEMP_3_226 TEMP_4_226 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_227 (TEMP_3_227 TEMP_4_227 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_228 (TEMP_3_228 TEMP_4_228 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_229 (TEMP_3_229 TEMP_4_229 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_230 (TEMP_3_230 TEMP_4_230 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_231 (TEMP_3_231 TEMP_4_231 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_232 (TEMP_3_232 TEMP_4_232 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_233 (TEMP_3_233 TEMP_4_233 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_234 (TEMP_3_234 TEMP_4_234 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_235 (TEMP_3_235 TEMP_4_235 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_236 (TEMP_3_236 TEMP_4_236 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_237 (TEMP_3_237 TEMP_4_237 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_238 (TEMP_3_238 TEMP_4_238 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_239 (TEMP_3_239 TEMP_4_239 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_240 (TEMP_3_240 TEMP_4_240 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_241 (TEMP_3_241 TEMP_4_241 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_242 (TEMP_3_242 TEMP_4_242 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_243 (TEMP_3_243 TEMP_4_243 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_244 (TEMP_3_244 TEMP_4_244 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_245 (TEMP_3_245 TEMP_4_245 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_246 (TEMP_3_246 TEMP_4_246 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_247 (TEMP_3_247 TEMP_4_247 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_248 (TEMP_3_248 TEMP_4_248 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_249 (TEMP_3_249 TEMP_4_249 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_250 (TEMP_3_250 TEMP_4_250 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_251 (TEMP_3_251 TEMP_4_251 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_252 (TEMP_3_252 TEMP_4_252 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_253 (TEMP_3_253 TEMP_4_253 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_254 (TEMP_3_254 TEMP_4_254 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_3_255 (TEMP_3_255 TEMP_4_255 vdd vss PBulkLine NBulkLine) inverter mult=1.0872796
xNOT_4_0 (TEMP_4_0 TEMP_5_0 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_1 (TEMP_4_1 TEMP_5_1 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_2 (TEMP_4_2 TEMP_5_2 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_3 (TEMP_4_3 TEMP_5_3 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_4 (TEMP_4_4 TEMP_5_4 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_5 (TEMP_4_5 TEMP_5_5 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_6 (TEMP_4_6 TEMP_5_6 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_7 (TEMP_4_7 TEMP_5_7 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_8 (TEMP_4_8 TEMP_5_8 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_9 (TEMP_4_9 TEMP_5_9 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_10 (TEMP_4_10 TEMP_5_10 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_11 (TEMP_4_11 TEMP_5_11 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_12 (TEMP_4_12 TEMP_5_12 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_13 (TEMP_4_13 TEMP_5_13 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_14 (TEMP_4_14 TEMP_5_14 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_15 (TEMP_4_15 TEMP_5_15 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_16 (TEMP_4_16 TEMP_5_16 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_17 (TEMP_4_17 TEMP_5_17 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_18 (TEMP_4_18 TEMP_5_18 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_19 (TEMP_4_19 TEMP_5_19 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_20 (TEMP_4_20 TEMP_5_20 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_21 (TEMP_4_21 TEMP_5_21 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_22 (TEMP_4_22 TEMP_5_22 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_23 (TEMP_4_23 TEMP_5_23 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_24 (TEMP_4_24 TEMP_5_24 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_25 (TEMP_4_25 TEMP_5_25 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_26 (TEMP_4_26 TEMP_5_26 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_27 (TEMP_4_27 TEMP_5_27 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_28 (TEMP_4_28 TEMP_5_28 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_29 (TEMP_4_29 TEMP_5_29 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_30 (TEMP_4_30 TEMP_5_30 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_31 (TEMP_4_31 TEMP_5_31 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_32 (TEMP_4_32 TEMP_5_32 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_33 (TEMP_4_33 TEMP_5_33 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_34 (TEMP_4_34 TEMP_5_34 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_35 (TEMP_4_35 TEMP_5_35 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_36 (TEMP_4_36 TEMP_5_36 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_37 (TEMP_4_37 TEMP_5_37 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_38 (TEMP_4_38 TEMP_5_38 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_39 (TEMP_4_39 TEMP_5_39 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_40 (TEMP_4_40 TEMP_5_40 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_41 (TEMP_4_41 TEMP_5_41 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_42 (TEMP_4_42 TEMP_5_42 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_43 (TEMP_4_43 TEMP_5_43 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_44 (TEMP_4_44 TEMP_5_44 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_45 (TEMP_4_45 TEMP_5_45 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_46 (TEMP_4_46 TEMP_5_46 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_47 (TEMP_4_47 TEMP_5_47 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_48 (TEMP_4_48 TEMP_5_48 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_49 (TEMP_4_49 TEMP_5_49 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_50 (TEMP_4_50 TEMP_5_50 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_51 (TEMP_4_51 TEMP_5_51 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_52 (TEMP_4_52 TEMP_5_52 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_53 (TEMP_4_53 TEMP_5_53 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_54 (TEMP_4_54 TEMP_5_54 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_55 (TEMP_4_55 TEMP_5_55 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_56 (TEMP_4_56 TEMP_5_56 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_57 (TEMP_4_57 TEMP_5_57 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_58 (TEMP_4_58 TEMP_5_58 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_59 (TEMP_4_59 TEMP_5_59 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_60 (TEMP_4_60 TEMP_5_60 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_61 (TEMP_4_61 TEMP_5_61 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_62 (TEMP_4_62 TEMP_5_62 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_63 (TEMP_4_63 TEMP_5_63 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_64 (TEMP_4_64 TEMP_5_64 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_65 (TEMP_4_65 TEMP_5_65 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_66 (TEMP_4_66 TEMP_5_66 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_67 (TEMP_4_67 TEMP_5_67 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_68 (TEMP_4_68 TEMP_5_68 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_69 (TEMP_4_69 TEMP_5_69 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_70 (TEMP_4_70 TEMP_5_70 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_71 (TEMP_4_71 TEMP_5_71 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_72 (TEMP_4_72 TEMP_5_72 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_73 (TEMP_4_73 TEMP_5_73 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_74 (TEMP_4_74 TEMP_5_74 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_75 (TEMP_4_75 TEMP_5_75 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_76 (TEMP_4_76 TEMP_5_76 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_77 (TEMP_4_77 TEMP_5_77 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_78 (TEMP_4_78 TEMP_5_78 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_79 (TEMP_4_79 TEMP_5_79 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_80 (TEMP_4_80 TEMP_5_80 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_81 (TEMP_4_81 TEMP_5_81 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_82 (TEMP_4_82 TEMP_5_82 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_83 (TEMP_4_83 TEMP_5_83 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_84 (TEMP_4_84 TEMP_5_84 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_85 (TEMP_4_85 TEMP_5_85 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_86 (TEMP_4_86 TEMP_5_86 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_87 (TEMP_4_87 TEMP_5_87 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_88 (TEMP_4_88 TEMP_5_88 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_89 (TEMP_4_89 TEMP_5_89 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_90 (TEMP_4_90 TEMP_5_90 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_91 (TEMP_4_91 TEMP_5_91 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_92 (TEMP_4_92 TEMP_5_92 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_93 (TEMP_4_93 TEMP_5_93 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_94 (TEMP_4_94 TEMP_5_94 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_95 (TEMP_4_95 TEMP_5_95 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_96 (TEMP_4_96 TEMP_5_96 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_97 (TEMP_4_97 TEMP_5_97 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_98 (TEMP_4_98 TEMP_5_98 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_99 (TEMP_4_99 TEMP_5_99 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_100 (TEMP_4_100 TEMP_5_100 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_101 (TEMP_4_101 TEMP_5_101 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_102 (TEMP_4_102 TEMP_5_102 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_103 (TEMP_4_103 TEMP_5_103 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_104 (TEMP_4_104 TEMP_5_104 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_105 (TEMP_4_105 TEMP_5_105 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_106 (TEMP_4_106 TEMP_5_106 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_107 (TEMP_4_107 TEMP_5_107 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_108 (TEMP_4_108 TEMP_5_108 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_109 (TEMP_4_109 TEMP_5_109 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_110 (TEMP_4_110 TEMP_5_110 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_111 (TEMP_4_111 TEMP_5_111 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_112 (TEMP_4_112 TEMP_5_112 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_113 (TEMP_4_113 TEMP_5_113 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_114 (TEMP_4_114 TEMP_5_114 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_115 (TEMP_4_115 TEMP_5_115 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_116 (TEMP_4_116 TEMP_5_116 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_117 (TEMP_4_117 TEMP_5_117 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_118 (TEMP_4_118 TEMP_5_118 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_119 (TEMP_4_119 TEMP_5_119 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_120 (TEMP_4_120 TEMP_5_120 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_121 (TEMP_4_121 TEMP_5_121 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_122 (TEMP_4_122 TEMP_5_122 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_123 (TEMP_4_123 TEMP_5_123 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_124 (TEMP_4_124 TEMP_5_124 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_125 (TEMP_4_125 TEMP_5_125 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_126 (TEMP_4_126 TEMP_5_126 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_127 (TEMP_4_127 TEMP_5_127 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_128 (TEMP_4_128 TEMP_5_128 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_129 (TEMP_4_129 TEMP_5_129 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_130 (TEMP_4_130 TEMP_5_130 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_131 (TEMP_4_131 TEMP_5_131 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_132 (TEMP_4_132 TEMP_5_132 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_133 (TEMP_4_133 TEMP_5_133 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_134 (TEMP_4_134 TEMP_5_134 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_135 (TEMP_4_135 TEMP_5_135 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_136 (TEMP_4_136 TEMP_5_136 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_137 (TEMP_4_137 TEMP_5_137 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_138 (TEMP_4_138 TEMP_5_138 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_139 (TEMP_4_139 TEMP_5_139 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_140 (TEMP_4_140 TEMP_5_140 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_141 (TEMP_4_141 TEMP_5_141 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_142 (TEMP_4_142 TEMP_5_142 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_143 (TEMP_4_143 TEMP_5_143 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_144 (TEMP_4_144 TEMP_5_144 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_145 (TEMP_4_145 TEMP_5_145 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_146 (TEMP_4_146 TEMP_5_146 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_147 (TEMP_4_147 TEMP_5_147 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_148 (TEMP_4_148 TEMP_5_148 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_149 (TEMP_4_149 TEMP_5_149 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_150 (TEMP_4_150 TEMP_5_150 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_151 (TEMP_4_151 TEMP_5_151 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_152 (TEMP_4_152 TEMP_5_152 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_153 (TEMP_4_153 TEMP_5_153 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_154 (TEMP_4_154 TEMP_5_154 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_155 (TEMP_4_155 TEMP_5_155 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_156 (TEMP_4_156 TEMP_5_156 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_157 (TEMP_4_157 TEMP_5_157 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_158 (TEMP_4_158 TEMP_5_158 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_159 (TEMP_4_159 TEMP_5_159 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_160 (TEMP_4_160 TEMP_5_160 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_161 (TEMP_4_161 TEMP_5_161 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_162 (TEMP_4_162 TEMP_5_162 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_163 (TEMP_4_163 TEMP_5_163 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_164 (TEMP_4_164 TEMP_5_164 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_165 (TEMP_4_165 TEMP_5_165 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_166 (TEMP_4_166 TEMP_5_166 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_167 (TEMP_4_167 TEMP_5_167 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_168 (TEMP_4_168 TEMP_5_168 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_169 (TEMP_4_169 TEMP_5_169 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_170 (TEMP_4_170 TEMP_5_170 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_171 (TEMP_4_171 TEMP_5_171 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_172 (TEMP_4_172 TEMP_5_172 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_173 (TEMP_4_173 TEMP_5_173 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_174 (TEMP_4_174 TEMP_5_174 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_175 (TEMP_4_175 TEMP_5_175 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_176 (TEMP_4_176 TEMP_5_176 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_177 (TEMP_4_177 TEMP_5_177 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_178 (TEMP_4_178 TEMP_5_178 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_179 (TEMP_4_179 TEMP_5_179 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_180 (TEMP_4_180 TEMP_5_180 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_181 (TEMP_4_181 TEMP_5_181 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_182 (TEMP_4_182 TEMP_5_182 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_183 (TEMP_4_183 TEMP_5_183 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_184 (TEMP_4_184 TEMP_5_184 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_185 (TEMP_4_185 TEMP_5_185 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_186 (TEMP_4_186 TEMP_5_186 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_187 (TEMP_4_187 TEMP_5_187 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_188 (TEMP_4_188 TEMP_5_188 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_189 (TEMP_4_189 TEMP_5_189 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_190 (TEMP_4_190 TEMP_5_190 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_191 (TEMP_4_191 TEMP_5_191 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_192 (TEMP_4_192 TEMP_5_192 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_193 (TEMP_4_193 TEMP_5_193 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_194 (TEMP_4_194 TEMP_5_194 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_195 (TEMP_4_195 TEMP_5_195 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_196 (TEMP_4_196 TEMP_5_196 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_197 (TEMP_4_197 TEMP_5_197 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_198 (TEMP_4_198 TEMP_5_198 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_199 (TEMP_4_199 TEMP_5_199 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_200 (TEMP_4_200 TEMP_5_200 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_201 (TEMP_4_201 TEMP_5_201 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_202 (TEMP_4_202 TEMP_5_202 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_203 (TEMP_4_203 TEMP_5_203 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_204 (TEMP_4_204 TEMP_5_204 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_205 (TEMP_4_205 TEMP_5_205 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_206 (TEMP_4_206 TEMP_5_206 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_207 (TEMP_4_207 TEMP_5_207 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_208 (TEMP_4_208 TEMP_5_208 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_209 (TEMP_4_209 TEMP_5_209 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_210 (TEMP_4_210 TEMP_5_210 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_211 (TEMP_4_211 TEMP_5_211 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_212 (TEMP_4_212 TEMP_5_212 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_213 (TEMP_4_213 TEMP_5_213 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_214 (TEMP_4_214 TEMP_5_214 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_215 (TEMP_4_215 TEMP_5_215 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_216 (TEMP_4_216 TEMP_5_216 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_217 (TEMP_4_217 TEMP_5_217 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_218 (TEMP_4_218 TEMP_5_218 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_219 (TEMP_4_219 TEMP_5_219 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_220 (TEMP_4_220 TEMP_5_220 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_221 (TEMP_4_221 TEMP_5_221 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_222 (TEMP_4_222 TEMP_5_222 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_223 (TEMP_4_223 TEMP_5_223 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_224 (TEMP_4_224 TEMP_5_224 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_225 (TEMP_4_225 TEMP_5_225 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_226 (TEMP_4_226 TEMP_5_226 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_227 (TEMP_4_227 TEMP_5_227 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_228 (TEMP_4_228 TEMP_5_228 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_229 (TEMP_4_229 TEMP_5_229 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_230 (TEMP_4_230 TEMP_5_230 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_231 (TEMP_4_231 TEMP_5_231 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_232 (TEMP_4_232 TEMP_5_232 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_233 (TEMP_4_233 TEMP_5_233 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_234 (TEMP_4_234 TEMP_5_234 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_235 (TEMP_4_235 TEMP_5_235 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_236 (TEMP_4_236 TEMP_5_236 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_237 (TEMP_4_237 TEMP_5_237 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_238 (TEMP_4_238 TEMP_5_238 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_239 (TEMP_4_239 TEMP_5_239 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_240 (TEMP_4_240 TEMP_5_240 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_241 (TEMP_4_241 TEMP_5_241 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_242 (TEMP_4_242 TEMP_5_242 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_243 (TEMP_4_243 TEMP_5_243 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_244 (TEMP_4_244 TEMP_5_244 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_245 (TEMP_4_245 TEMP_5_245 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_246 (TEMP_4_246 TEMP_5_246 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_247 (TEMP_4_247 TEMP_5_247 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_248 (TEMP_4_248 TEMP_5_248 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_249 (TEMP_4_249 TEMP_5_249 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_250 (TEMP_4_250 TEMP_5_250 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_251 (TEMP_4_251 TEMP_5_251 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_252 (TEMP_4_252 TEMP_5_252 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_253 (TEMP_4_253 TEMP_5_253 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_254 (TEMP_4_254 TEMP_5_254 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_4_255 (TEMP_4_255 TEMP_5_255 vdd vss PBulkLine NBulkLine) inverter mult=1.118034
xNOT_5_0 (TEMP_5_0 TEMP_6_0 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_1 (TEMP_5_1 TEMP_6_1 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_2 (TEMP_5_2 TEMP_6_2 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_3 (TEMP_5_3 TEMP_6_3 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_4 (TEMP_5_4 TEMP_6_4 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_5 (TEMP_5_5 TEMP_6_5 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_6 (TEMP_5_6 TEMP_6_6 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_7 (TEMP_5_7 TEMP_6_7 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_8 (TEMP_5_8 TEMP_6_8 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_9 (TEMP_5_9 TEMP_6_9 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_10 (TEMP_5_10 TEMP_6_10 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_11 (TEMP_5_11 TEMP_6_11 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_12 (TEMP_5_12 TEMP_6_12 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_13 (TEMP_5_13 TEMP_6_13 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_14 (TEMP_5_14 TEMP_6_14 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_15 (TEMP_5_15 TEMP_6_15 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_16 (TEMP_5_16 TEMP_6_16 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_17 (TEMP_5_17 TEMP_6_17 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_18 (TEMP_5_18 TEMP_6_18 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_19 (TEMP_5_19 TEMP_6_19 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_20 (TEMP_5_20 TEMP_6_20 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_21 (TEMP_5_21 TEMP_6_21 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_22 (TEMP_5_22 TEMP_6_22 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_23 (TEMP_5_23 TEMP_6_23 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_24 (TEMP_5_24 TEMP_6_24 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_25 (TEMP_5_25 TEMP_6_25 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_26 (TEMP_5_26 TEMP_6_26 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_27 (TEMP_5_27 TEMP_6_27 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_28 (TEMP_5_28 TEMP_6_28 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_29 (TEMP_5_29 TEMP_6_29 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_30 (TEMP_5_30 TEMP_6_30 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_31 (TEMP_5_31 TEMP_6_31 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_32 (TEMP_5_32 TEMP_6_32 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_33 (TEMP_5_33 TEMP_6_33 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_34 (TEMP_5_34 TEMP_6_34 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_35 (TEMP_5_35 TEMP_6_35 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_36 (TEMP_5_36 TEMP_6_36 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_37 (TEMP_5_37 TEMP_6_37 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_38 (TEMP_5_38 TEMP_6_38 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_39 (TEMP_5_39 TEMP_6_39 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_40 (TEMP_5_40 TEMP_6_40 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_41 (TEMP_5_41 TEMP_6_41 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_42 (TEMP_5_42 TEMP_6_42 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_43 (TEMP_5_43 TEMP_6_43 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_44 (TEMP_5_44 TEMP_6_44 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_45 (TEMP_5_45 TEMP_6_45 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_46 (TEMP_5_46 TEMP_6_46 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_47 (TEMP_5_47 TEMP_6_47 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_48 (TEMP_5_48 TEMP_6_48 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_49 (TEMP_5_49 TEMP_6_49 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_50 (TEMP_5_50 TEMP_6_50 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_51 (TEMP_5_51 TEMP_6_51 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_52 (TEMP_5_52 TEMP_6_52 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_53 (TEMP_5_53 TEMP_6_53 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_54 (TEMP_5_54 TEMP_6_54 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_55 (TEMP_5_55 TEMP_6_55 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_56 (TEMP_5_56 TEMP_6_56 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_57 (TEMP_5_57 TEMP_6_57 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_58 (TEMP_5_58 TEMP_6_58 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_59 (TEMP_5_59 TEMP_6_59 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_60 (TEMP_5_60 TEMP_6_60 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_61 (TEMP_5_61 TEMP_6_61 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_62 (TEMP_5_62 TEMP_6_62 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_63 (TEMP_5_63 TEMP_6_63 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_64 (TEMP_5_64 TEMP_6_64 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_65 (TEMP_5_65 TEMP_6_65 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_66 (TEMP_5_66 TEMP_6_66 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_67 (TEMP_5_67 TEMP_6_67 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_68 (TEMP_5_68 TEMP_6_68 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_69 (TEMP_5_69 TEMP_6_69 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_70 (TEMP_5_70 TEMP_6_70 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_71 (TEMP_5_71 TEMP_6_71 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_72 (TEMP_5_72 TEMP_6_72 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_73 (TEMP_5_73 TEMP_6_73 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_74 (TEMP_5_74 TEMP_6_74 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_75 (TEMP_5_75 TEMP_6_75 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_76 (TEMP_5_76 TEMP_6_76 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_77 (TEMP_5_77 TEMP_6_77 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_78 (TEMP_5_78 TEMP_6_78 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_79 (TEMP_5_79 TEMP_6_79 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_80 (TEMP_5_80 TEMP_6_80 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_81 (TEMP_5_81 TEMP_6_81 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_82 (TEMP_5_82 TEMP_6_82 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_83 (TEMP_5_83 TEMP_6_83 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_84 (TEMP_5_84 TEMP_6_84 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_85 (TEMP_5_85 TEMP_6_85 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_86 (TEMP_5_86 TEMP_6_86 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_87 (TEMP_5_87 TEMP_6_87 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_88 (TEMP_5_88 TEMP_6_88 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_89 (TEMP_5_89 TEMP_6_89 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_90 (TEMP_5_90 TEMP_6_90 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_91 (TEMP_5_91 TEMP_6_91 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_92 (TEMP_5_92 TEMP_6_92 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_93 (TEMP_5_93 TEMP_6_93 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_94 (TEMP_5_94 TEMP_6_94 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_95 (TEMP_5_95 TEMP_6_95 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_96 (TEMP_5_96 TEMP_6_96 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_97 (TEMP_5_97 TEMP_6_97 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_98 (TEMP_5_98 TEMP_6_98 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_99 (TEMP_5_99 TEMP_6_99 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_100 (TEMP_5_100 TEMP_6_100 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_101 (TEMP_5_101 TEMP_6_101 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_102 (TEMP_5_102 TEMP_6_102 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_103 (TEMP_5_103 TEMP_6_103 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_104 (TEMP_5_104 TEMP_6_104 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_105 (TEMP_5_105 TEMP_6_105 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_106 (TEMP_5_106 TEMP_6_106 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_107 (TEMP_5_107 TEMP_6_107 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_108 (TEMP_5_108 TEMP_6_108 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_109 (TEMP_5_109 TEMP_6_109 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_110 (TEMP_5_110 TEMP_6_110 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_111 (TEMP_5_111 TEMP_6_111 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_112 (TEMP_5_112 TEMP_6_112 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_113 (TEMP_5_113 TEMP_6_113 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_114 (TEMP_5_114 TEMP_6_114 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_115 (TEMP_5_115 TEMP_6_115 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_116 (TEMP_5_116 TEMP_6_116 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_117 (TEMP_5_117 TEMP_6_117 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_118 (TEMP_5_118 TEMP_6_118 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_119 (TEMP_5_119 TEMP_6_119 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_120 (TEMP_5_120 TEMP_6_120 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_121 (TEMP_5_121 TEMP_6_121 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_122 (TEMP_5_122 TEMP_6_122 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_123 (TEMP_5_123 TEMP_6_123 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_124 (TEMP_5_124 TEMP_6_124 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_125 (TEMP_5_125 TEMP_6_125 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_126 (TEMP_5_126 TEMP_6_126 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_127 (TEMP_5_127 TEMP_6_127 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_128 (TEMP_5_128 TEMP_6_128 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_129 (TEMP_5_129 TEMP_6_129 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_130 (TEMP_5_130 TEMP_6_130 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_131 (TEMP_5_131 TEMP_6_131 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_132 (TEMP_5_132 TEMP_6_132 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_133 (TEMP_5_133 TEMP_6_133 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_134 (TEMP_5_134 TEMP_6_134 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_135 (TEMP_5_135 TEMP_6_135 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_136 (TEMP_5_136 TEMP_6_136 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_137 (TEMP_5_137 TEMP_6_137 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_138 (TEMP_5_138 TEMP_6_138 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_139 (TEMP_5_139 TEMP_6_139 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_140 (TEMP_5_140 TEMP_6_140 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_141 (TEMP_5_141 TEMP_6_141 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_142 (TEMP_5_142 TEMP_6_142 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_143 (TEMP_5_143 TEMP_6_143 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_144 (TEMP_5_144 TEMP_6_144 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_145 (TEMP_5_145 TEMP_6_145 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_146 (TEMP_5_146 TEMP_6_146 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_147 (TEMP_5_147 TEMP_6_147 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_148 (TEMP_5_148 TEMP_6_148 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_149 (TEMP_5_149 TEMP_6_149 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_150 (TEMP_5_150 TEMP_6_150 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_151 (TEMP_5_151 TEMP_6_151 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_152 (TEMP_5_152 TEMP_6_152 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_153 (TEMP_5_153 TEMP_6_153 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_154 (TEMP_5_154 TEMP_6_154 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_155 (TEMP_5_155 TEMP_6_155 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_156 (TEMP_5_156 TEMP_6_156 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_157 (TEMP_5_157 TEMP_6_157 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_158 (TEMP_5_158 TEMP_6_158 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_159 (TEMP_5_159 TEMP_6_159 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_160 (TEMP_5_160 TEMP_6_160 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_161 (TEMP_5_161 TEMP_6_161 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_162 (TEMP_5_162 TEMP_6_162 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_163 (TEMP_5_163 TEMP_6_163 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_164 (TEMP_5_164 TEMP_6_164 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_165 (TEMP_5_165 TEMP_6_165 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_166 (TEMP_5_166 TEMP_6_166 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_167 (TEMP_5_167 TEMP_6_167 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_168 (TEMP_5_168 TEMP_6_168 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_169 (TEMP_5_169 TEMP_6_169 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_170 (TEMP_5_170 TEMP_6_170 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_171 (TEMP_5_171 TEMP_6_171 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_172 (TEMP_5_172 TEMP_6_172 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_173 (TEMP_5_173 TEMP_6_173 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_174 (TEMP_5_174 TEMP_6_174 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_175 (TEMP_5_175 TEMP_6_175 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_176 (TEMP_5_176 TEMP_6_176 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_177 (TEMP_5_177 TEMP_6_177 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_178 (TEMP_5_178 TEMP_6_178 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_179 (TEMP_5_179 TEMP_6_179 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_180 (TEMP_5_180 TEMP_6_180 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_181 (TEMP_5_181 TEMP_6_181 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_182 (TEMP_5_182 TEMP_6_182 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_183 (TEMP_5_183 TEMP_6_183 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_184 (TEMP_5_184 TEMP_6_184 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_185 (TEMP_5_185 TEMP_6_185 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_186 (TEMP_5_186 TEMP_6_186 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_187 (TEMP_5_187 TEMP_6_187 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_188 (TEMP_5_188 TEMP_6_188 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_189 (TEMP_5_189 TEMP_6_189 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_190 (TEMP_5_190 TEMP_6_190 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_191 (TEMP_5_191 TEMP_6_191 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_192 (TEMP_5_192 TEMP_6_192 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_193 (TEMP_5_193 TEMP_6_193 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_194 (TEMP_5_194 TEMP_6_194 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_195 (TEMP_5_195 TEMP_6_195 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_196 (TEMP_5_196 TEMP_6_196 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_197 (TEMP_5_197 TEMP_6_197 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_198 (TEMP_5_198 TEMP_6_198 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_199 (TEMP_5_199 TEMP_6_199 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_200 (TEMP_5_200 TEMP_6_200 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_201 (TEMP_5_201 TEMP_6_201 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_202 (TEMP_5_202 TEMP_6_202 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_203 (TEMP_5_203 TEMP_6_203 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_204 (TEMP_5_204 TEMP_6_204 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_205 (TEMP_5_205 TEMP_6_205 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_206 (TEMP_5_206 TEMP_6_206 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_207 (TEMP_5_207 TEMP_6_207 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_208 (TEMP_5_208 TEMP_6_208 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_209 (TEMP_5_209 TEMP_6_209 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_210 (TEMP_5_210 TEMP_6_210 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_211 (TEMP_5_211 TEMP_6_211 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_212 (TEMP_5_212 TEMP_6_212 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_213 (TEMP_5_213 TEMP_6_213 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_214 (TEMP_5_214 TEMP_6_214 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_215 (TEMP_5_215 TEMP_6_215 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_216 (TEMP_5_216 TEMP_6_216 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_217 (TEMP_5_217 TEMP_6_217 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_218 (TEMP_5_218 TEMP_6_218 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_219 (TEMP_5_219 TEMP_6_219 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_220 (TEMP_5_220 TEMP_6_220 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_221 (TEMP_5_221 TEMP_6_221 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_222 (TEMP_5_222 TEMP_6_222 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_223 (TEMP_5_223 TEMP_6_223 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_224 (TEMP_5_224 TEMP_6_224 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_225 (TEMP_5_225 TEMP_6_225 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_226 (TEMP_5_226 TEMP_6_226 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_227 (TEMP_5_227 TEMP_6_227 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_228 (TEMP_5_228 TEMP_6_228 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_229 (TEMP_5_229 TEMP_6_229 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_230 (TEMP_5_230 TEMP_6_230 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_231 (TEMP_5_231 TEMP_6_231 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_232 (TEMP_5_232 TEMP_6_232 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_233 (TEMP_5_233 TEMP_6_233 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_234 (TEMP_5_234 TEMP_6_234 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_235 (TEMP_5_235 TEMP_6_235 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_236 (TEMP_5_236 TEMP_6_236 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_237 (TEMP_5_237 TEMP_6_237 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_238 (TEMP_5_238 TEMP_6_238 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_239 (TEMP_5_239 TEMP_6_239 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_240 (TEMP_5_240 TEMP_6_240 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_241 (TEMP_5_241 TEMP_6_241 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_242 (TEMP_5_242 TEMP_6_242 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_243 (TEMP_5_243 TEMP_6_243 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_244 (TEMP_5_244 TEMP_6_244 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_245 (TEMP_5_245 TEMP_6_245 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_246 (TEMP_5_246 TEMP_6_246 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_247 (TEMP_5_247 TEMP_6_247 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_248 (TEMP_5_248 TEMP_6_248 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_249 (TEMP_5_249 TEMP_6_249 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_250 (TEMP_5_250 TEMP_6_250 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_251 (TEMP_5_251 TEMP_6_251 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_252 (TEMP_5_252 TEMP_6_252 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_253 (TEMP_5_253 TEMP_6_253 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_254 (TEMP_5_254 TEMP_6_254 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_5_255 (TEMP_5_255 TEMP_6_255 vdd vss PBulkLine NBulkLine) inverter mult=1.1496582
xNOT_6_0 (TEMP_6_0 TEMP_7_0 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_1 (TEMP_6_1 TEMP_7_1 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_2 (TEMP_6_2 TEMP_7_2 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_3 (TEMP_6_3 TEMP_7_3 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_4 (TEMP_6_4 TEMP_7_4 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_5 (TEMP_6_5 TEMP_7_5 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_6 (TEMP_6_6 TEMP_7_6 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_7 (TEMP_6_7 TEMP_7_7 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_8 (TEMP_6_8 TEMP_7_8 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_9 (TEMP_6_9 TEMP_7_9 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_10 (TEMP_6_10 TEMP_7_10 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_11 (TEMP_6_11 TEMP_7_11 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_12 (TEMP_6_12 TEMP_7_12 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_13 (TEMP_6_13 TEMP_7_13 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_14 (TEMP_6_14 TEMP_7_14 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_15 (TEMP_6_15 TEMP_7_15 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_16 (TEMP_6_16 TEMP_7_16 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_17 (TEMP_6_17 TEMP_7_17 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_18 (TEMP_6_18 TEMP_7_18 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_19 (TEMP_6_19 TEMP_7_19 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_20 (TEMP_6_20 TEMP_7_20 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_21 (TEMP_6_21 TEMP_7_21 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_22 (TEMP_6_22 TEMP_7_22 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_23 (TEMP_6_23 TEMP_7_23 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_24 (TEMP_6_24 TEMP_7_24 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_25 (TEMP_6_25 TEMP_7_25 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_26 (TEMP_6_26 TEMP_7_26 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_27 (TEMP_6_27 TEMP_7_27 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_28 (TEMP_6_28 TEMP_7_28 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_29 (TEMP_6_29 TEMP_7_29 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_30 (TEMP_6_30 TEMP_7_30 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_31 (TEMP_6_31 TEMP_7_31 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_32 (TEMP_6_32 TEMP_7_32 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_33 (TEMP_6_33 TEMP_7_33 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_34 (TEMP_6_34 TEMP_7_34 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_35 (TEMP_6_35 TEMP_7_35 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_36 (TEMP_6_36 TEMP_7_36 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_37 (TEMP_6_37 TEMP_7_37 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_38 (TEMP_6_38 TEMP_7_38 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_39 (TEMP_6_39 TEMP_7_39 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_40 (TEMP_6_40 TEMP_7_40 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_41 (TEMP_6_41 TEMP_7_41 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_42 (TEMP_6_42 TEMP_7_42 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_43 (TEMP_6_43 TEMP_7_43 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_44 (TEMP_6_44 TEMP_7_44 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_45 (TEMP_6_45 TEMP_7_45 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_46 (TEMP_6_46 TEMP_7_46 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_47 (TEMP_6_47 TEMP_7_47 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_48 (TEMP_6_48 TEMP_7_48 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_49 (TEMP_6_49 TEMP_7_49 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_50 (TEMP_6_50 TEMP_7_50 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_51 (TEMP_6_51 TEMP_7_51 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_52 (TEMP_6_52 TEMP_7_52 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_53 (TEMP_6_53 TEMP_7_53 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_54 (TEMP_6_54 TEMP_7_54 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_55 (TEMP_6_55 TEMP_7_55 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_56 (TEMP_6_56 TEMP_7_56 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_57 (TEMP_6_57 TEMP_7_57 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_58 (TEMP_6_58 TEMP_7_58 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_59 (TEMP_6_59 TEMP_7_59 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_60 (TEMP_6_60 TEMP_7_60 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_61 (TEMP_6_61 TEMP_7_61 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_62 (TEMP_6_62 TEMP_7_62 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_63 (TEMP_6_63 TEMP_7_63 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_64 (TEMP_6_64 TEMP_7_64 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_65 (TEMP_6_65 TEMP_7_65 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_66 (TEMP_6_66 TEMP_7_66 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_67 (TEMP_6_67 TEMP_7_67 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_68 (TEMP_6_68 TEMP_7_68 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_69 (TEMP_6_69 TEMP_7_69 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_70 (TEMP_6_70 TEMP_7_70 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_71 (TEMP_6_71 TEMP_7_71 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_72 (TEMP_6_72 TEMP_7_72 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_73 (TEMP_6_73 TEMP_7_73 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_74 (TEMP_6_74 TEMP_7_74 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_75 (TEMP_6_75 TEMP_7_75 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_76 (TEMP_6_76 TEMP_7_76 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_77 (TEMP_6_77 TEMP_7_77 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_78 (TEMP_6_78 TEMP_7_78 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_79 (TEMP_6_79 TEMP_7_79 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_80 (TEMP_6_80 TEMP_7_80 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_81 (TEMP_6_81 TEMP_7_81 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_82 (TEMP_6_82 TEMP_7_82 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_83 (TEMP_6_83 TEMP_7_83 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_84 (TEMP_6_84 TEMP_7_84 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_85 (TEMP_6_85 TEMP_7_85 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_86 (TEMP_6_86 TEMP_7_86 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_87 (TEMP_6_87 TEMP_7_87 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_88 (TEMP_6_88 TEMP_7_88 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_89 (TEMP_6_89 TEMP_7_89 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_90 (TEMP_6_90 TEMP_7_90 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_91 (TEMP_6_91 TEMP_7_91 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_92 (TEMP_6_92 TEMP_7_92 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_93 (TEMP_6_93 TEMP_7_93 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_94 (TEMP_6_94 TEMP_7_94 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_95 (TEMP_6_95 TEMP_7_95 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_96 (TEMP_6_96 TEMP_7_96 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_97 (TEMP_6_97 TEMP_7_97 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_98 (TEMP_6_98 TEMP_7_98 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_99 (TEMP_6_99 TEMP_7_99 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_100 (TEMP_6_100 TEMP_7_100 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_101 (TEMP_6_101 TEMP_7_101 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_102 (TEMP_6_102 TEMP_7_102 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_103 (TEMP_6_103 TEMP_7_103 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_104 (TEMP_6_104 TEMP_7_104 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_105 (TEMP_6_105 TEMP_7_105 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_106 (TEMP_6_106 TEMP_7_106 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_107 (TEMP_6_107 TEMP_7_107 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_108 (TEMP_6_108 TEMP_7_108 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_109 (TEMP_6_109 TEMP_7_109 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_110 (TEMP_6_110 TEMP_7_110 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_111 (TEMP_6_111 TEMP_7_111 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_112 (TEMP_6_112 TEMP_7_112 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_113 (TEMP_6_113 TEMP_7_113 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_114 (TEMP_6_114 TEMP_7_114 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_115 (TEMP_6_115 TEMP_7_115 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_116 (TEMP_6_116 TEMP_7_116 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_117 (TEMP_6_117 TEMP_7_117 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_118 (TEMP_6_118 TEMP_7_118 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_119 (TEMP_6_119 TEMP_7_119 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_120 (TEMP_6_120 TEMP_7_120 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_121 (TEMP_6_121 TEMP_7_121 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_122 (TEMP_6_122 TEMP_7_122 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_123 (TEMP_6_123 TEMP_7_123 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_124 (TEMP_6_124 TEMP_7_124 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_125 (TEMP_6_125 TEMP_7_125 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_126 (TEMP_6_126 TEMP_7_126 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_127 (TEMP_6_127 TEMP_7_127 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_128 (TEMP_6_128 TEMP_7_128 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_129 (TEMP_6_129 TEMP_7_129 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_130 (TEMP_6_130 TEMP_7_130 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_131 (TEMP_6_131 TEMP_7_131 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_132 (TEMP_6_132 TEMP_7_132 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_133 (TEMP_6_133 TEMP_7_133 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_134 (TEMP_6_134 TEMP_7_134 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_135 (TEMP_6_135 TEMP_7_135 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_136 (TEMP_6_136 TEMP_7_136 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_137 (TEMP_6_137 TEMP_7_137 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_138 (TEMP_6_138 TEMP_7_138 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_139 (TEMP_6_139 TEMP_7_139 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_140 (TEMP_6_140 TEMP_7_140 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_141 (TEMP_6_141 TEMP_7_141 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_142 (TEMP_6_142 TEMP_7_142 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_143 (TEMP_6_143 TEMP_7_143 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_144 (TEMP_6_144 TEMP_7_144 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_145 (TEMP_6_145 TEMP_7_145 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_146 (TEMP_6_146 TEMP_7_146 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_147 (TEMP_6_147 TEMP_7_147 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_148 (TEMP_6_148 TEMP_7_148 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_149 (TEMP_6_149 TEMP_7_149 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_150 (TEMP_6_150 TEMP_7_150 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_151 (TEMP_6_151 TEMP_7_151 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_152 (TEMP_6_152 TEMP_7_152 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_153 (TEMP_6_153 TEMP_7_153 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_154 (TEMP_6_154 TEMP_7_154 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_155 (TEMP_6_155 TEMP_7_155 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_156 (TEMP_6_156 TEMP_7_156 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_157 (TEMP_6_157 TEMP_7_157 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_158 (TEMP_6_158 TEMP_7_158 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_159 (TEMP_6_159 TEMP_7_159 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_160 (TEMP_6_160 TEMP_7_160 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_161 (TEMP_6_161 TEMP_7_161 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_162 (TEMP_6_162 TEMP_7_162 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_163 (TEMP_6_163 TEMP_7_163 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_164 (TEMP_6_164 TEMP_7_164 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_165 (TEMP_6_165 TEMP_7_165 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_166 (TEMP_6_166 TEMP_7_166 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_167 (TEMP_6_167 TEMP_7_167 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_168 (TEMP_6_168 TEMP_7_168 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_169 (TEMP_6_169 TEMP_7_169 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_170 (TEMP_6_170 TEMP_7_170 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_171 (TEMP_6_171 TEMP_7_171 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_172 (TEMP_6_172 TEMP_7_172 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_173 (TEMP_6_173 TEMP_7_173 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_174 (TEMP_6_174 TEMP_7_174 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_175 (TEMP_6_175 TEMP_7_175 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_176 (TEMP_6_176 TEMP_7_176 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_177 (TEMP_6_177 TEMP_7_177 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_178 (TEMP_6_178 TEMP_7_178 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_179 (TEMP_6_179 TEMP_7_179 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_180 (TEMP_6_180 TEMP_7_180 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_181 (TEMP_6_181 TEMP_7_181 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_182 (TEMP_6_182 TEMP_7_182 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_183 (TEMP_6_183 TEMP_7_183 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_184 (TEMP_6_184 TEMP_7_184 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_185 (TEMP_6_185 TEMP_7_185 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_186 (TEMP_6_186 TEMP_7_186 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_187 (TEMP_6_187 TEMP_7_187 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_188 (TEMP_6_188 TEMP_7_188 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_189 (TEMP_6_189 TEMP_7_189 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_190 (TEMP_6_190 TEMP_7_190 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_191 (TEMP_6_191 TEMP_7_191 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_192 (TEMP_6_192 TEMP_7_192 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_193 (TEMP_6_193 TEMP_7_193 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_194 (TEMP_6_194 TEMP_7_194 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_195 (TEMP_6_195 TEMP_7_195 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_196 (TEMP_6_196 TEMP_7_196 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_197 (TEMP_6_197 TEMP_7_197 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_198 (TEMP_6_198 TEMP_7_198 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_199 (TEMP_6_199 TEMP_7_199 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_200 (TEMP_6_200 TEMP_7_200 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_201 (TEMP_6_201 TEMP_7_201 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_202 (TEMP_6_202 TEMP_7_202 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_203 (TEMP_6_203 TEMP_7_203 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_204 (TEMP_6_204 TEMP_7_204 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_205 (TEMP_6_205 TEMP_7_205 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_206 (TEMP_6_206 TEMP_7_206 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_207 (TEMP_6_207 TEMP_7_207 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_208 (TEMP_6_208 TEMP_7_208 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_209 (TEMP_6_209 TEMP_7_209 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_210 (TEMP_6_210 TEMP_7_210 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_211 (TEMP_6_211 TEMP_7_211 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_212 (TEMP_6_212 TEMP_7_212 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_213 (TEMP_6_213 TEMP_7_213 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_214 (TEMP_6_214 TEMP_7_214 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_215 (TEMP_6_215 TEMP_7_215 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_216 (TEMP_6_216 TEMP_7_216 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_217 (TEMP_6_217 TEMP_7_217 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_218 (TEMP_6_218 TEMP_7_218 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_219 (TEMP_6_219 TEMP_7_219 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_220 (TEMP_6_220 TEMP_7_220 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_221 (TEMP_6_221 TEMP_7_221 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_222 (TEMP_6_222 TEMP_7_222 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_223 (TEMP_6_223 TEMP_7_223 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_224 (TEMP_6_224 TEMP_7_224 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_225 (TEMP_6_225 TEMP_7_225 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_226 (TEMP_6_226 TEMP_7_226 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_227 (TEMP_6_227 TEMP_7_227 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_228 (TEMP_6_228 TEMP_7_228 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_229 (TEMP_6_229 TEMP_7_229 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_230 (TEMP_6_230 TEMP_7_230 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_231 (TEMP_6_231 TEMP_7_231 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_232 (TEMP_6_232 TEMP_7_232 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_233 (TEMP_6_233 TEMP_7_233 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_234 (TEMP_6_234 TEMP_7_234 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_235 (TEMP_6_235 TEMP_7_235 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_236 (TEMP_6_236 TEMP_7_236 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_237 (TEMP_6_237 TEMP_7_237 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_238 (TEMP_6_238 TEMP_7_238 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_239 (TEMP_6_239 TEMP_7_239 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_240 (TEMP_6_240 TEMP_7_240 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_241 (TEMP_6_241 TEMP_7_241 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_242 (TEMP_6_242 TEMP_7_242 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_243 (TEMP_6_243 TEMP_7_243 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_244 (TEMP_6_244 TEMP_7_244 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_245 (TEMP_6_245 TEMP_7_245 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_246 (TEMP_6_246 TEMP_7_246 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_247 (TEMP_6_247 TEMP_7_247 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_248 (TEMP_6_248 TEMP_7_248 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_249 (TEMP_6_249 TEMP_7_249 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_250 (TEMP_6_250 TEMP_7_250 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_251 (TEMP_6_251 TEMP_7_251 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_252 (TEMP_6_252 TEMP_7_252 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_253 (TEMP_6_253 TEMP_7_253 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_254 (TEMP_6_254 TEMP_7_254 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_6_255 (TEMP_6_255 TEMP_7_255 vdd vss PBulkLine NBulkLine) inverter mult=1.182177
xNOT_7_0 (TEMP_7_0 OUT_0 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_1 (TEMP_7_1 OUT_1 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_2 (TEMP_7_2 OUT_2 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_3 (TEMP_7_3 OUT_3 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_4 (TEMP_7_4 OUT_4 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_5 (TEMP_7_5 OUT_5 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_6 (TEMP_7_6 OUT_6 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_7 (TEMP_7_7 OUT_7 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_8 (TEMP_7_8 OUT_8 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_9 (TEMP_7_9 OUT_9 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_10 (TEMP_7_10 OUT_10 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_11 (TEMP_7_11 OUT_11 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_12 (TEMP_7_12 OUT_12 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_13 (TEMP_7_13 OUT_13 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_14 (TEMP_7_14 OUT_14 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_15 (TEMP_7_15 OUT_15 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_16 (TEMP_7_16 OUT_16 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_17 (TEMP_7_17 OUT_17 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_18 (TEMP_7_18 OUT_18 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_19 (TEMP_7_19 OUT_19 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_20 (TEMP_7_20 OUT_20 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_21 (TEMP_7_21 OUT_21 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_22 (TEMP_7_22 OUT_22 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_23 (TEMP_7_23 OUT_23 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_24 (TEMP_7_24 OUT_24 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_25 (TEMP_7_25 OUT_25 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_26 (TEMP_7_26 OUT_26 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_27 (TEMP_7_27 OUT_27 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_28 (TEMP_7_28 OUT_28 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_29 (TEMP_7_29 OUT_29 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_30 (TEMP_7_30 OUT_30 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_31 (TEMP_7_31 OUT_31 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_32 (TEMP_7_32 OUT_32 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_33 (TEMP_7_33 OUT_33 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_34 (TEMP_7_34 OUT_34 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_35 (TEMP_7_35 OUT_35 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_36 (TEMP_7_36 OUT_36 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_37 (TEMP_7_37 OUT_37 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_38 (TEMP_7_38 OUT_38 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_39 (TEMP_7_39 OUT_39 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_40 (TEMP_7_40 OUT_40 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_41 (TEMP_7_41 OUT_41 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_42 (TEMP_7_42 OUT_42 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_43 (TEMP_7_43 OUT_43 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_44 (TEMP_7_44 OUT_44 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_45 (TEMP_7_45 OUT_45 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_46 (TEMP_7_46 OUT_46 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_47 (TEMP_7_47 OUT_47 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_48 (TEMP_7_48 OUT_48 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_49 (TEMP_7_49 OUT_49 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_50 (TEMP_7_50 OUT_50 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_51 (TEMP_7_51 OUT_51 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_52 (TEMP_7_52 OUT_52 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_53 (TEMP_7_53 OUT_53 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_54 (TEMP_7_54 OUT_54 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_55 (TEMP_7_55 OUT_55 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_56 (TEMP_7_56 OUT_56 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_57 (TEMP_7_57 OUT_57 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_58 (TEMP_7_58 OUT_58 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_59 (TEMP_7_59 OUT_59 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_60 (TEMP_7_60 OUT_60 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_61 (TEMP_7_61 OUT_61 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_62 (TEMP_7_62 OUT_62 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_63 (TEMP_7_63 OUT_63 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_64 (TEMP_7_64 OUT_64 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_65 (TEMP_7_65 OUT_65 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_66 (TEMP_7_66 OUT_66 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_67 (TEMP_7_67 OUT_67 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_68 (TEMP_7_68 OUT_68 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_69 (TEMP_7_69 OUT_69 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_70 (TEMP_7_70 OUT_70 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_71 (TEMP_7_71 OUT_71 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_72 (TEMP_7_72 OUT_72 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_73 (TEMP_7_73 OUT_73 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_74 (TEMP_7_74 OUT_74 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_75 (TEMP_7_75 OUT_75 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_76 (TEMP_7_76 OUT_76 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_77 (TEMP_7_77 OUT_77 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_78 (TEMP_7_78 OUT_78 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_79 (TEMP_7_79 OUT_79 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_80 (TEMP_7_80 OUT_80 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_81 (TEMP_7_81 OUT_81 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_82 (TEMP_7_82 OUT_82 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_83 (TEMP_7_83 OUT_83 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_84 (TEMP_7_84 OUT_84 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_85 (TEMP_7_85 OUT_85 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_86 (TEMP_7_86 OUT_86 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_87 (TEMP_7_87 OUT_87 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_88 (TEMP_7_88 OUT_88 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_89 (TEMP_7_89 OUT_89 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_90 (TEMP_7_90 OUT_90 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_91 (TEMP_7_91 OUT_91 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_92 (TEMP_7_92 OUT_92 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_93 (TEMP_7_93 OUT_93 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_94 (TEMP_7_94 OUT_94 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_95 (TEMP_7_95 OUT_95 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_96 (TEMP_7_96 OUT_96 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_97 (TEMP_7_97 OUT_97 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_98 (TEMP_7_98 OUT_98 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_99 (TEMP_7_99 OUT_99 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_100 (TEMP_7_100 OUT_100 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_101 (TEMP_7_101 OUT_101 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_102 (TEMP_7_102 OUT_102 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_103 (TEMP_7_103 OUT_103 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_104 (TEMP_7_104 OUT_104 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_105 (TEMP_7_105 OUT_105 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_106 (TEMP_7_106 OUT_106 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_107 (TEMP_7_107 OUT_107 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_108 (TEMP_7_108 OUT_108 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_109 (TEMP_7_109 OUT_109 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_110 (TEMP_7_110 OUT_110 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_111 (TEMP_7_111 OUT_111 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_112 (TEMP_7_112 OUT_112 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_113 (TEMP_7_113 OUT_113 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_114 (TEMP_7_114 OUT_114 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_115 (TEMP_7_115 OUT_115 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_116 (TEMP_7_116 OUT_116 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_117 (TEMP_7_117 OUT_117 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_118 (TEMP_7_118 OUT_118 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_119 (TEMP_7_119 OUT_119 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_120 (TEMP_7_120 OUT_120 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_121 (TEMP_7_121 OUT_121 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_122 (TEMP_7_122 OUT_122 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_123 (TEMP_7_123 OUT_123 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_124 (TEMP_7_124 OUT_124 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_125 (TEMP_7_125 OUT_125 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_126 (TEMP_7_126 OUT_126 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_127 (TEMP_7_127 OUT_127 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_128 (TEMP_7_128 OUT_128 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_129 (TEMP_7_129 OUT_129 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_130 (TEMP_7_130 OUT_130 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_131 (TEMP_7_131 OUT_131 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_132 (TEMP_7_132 OUT_132 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_133 (TEMP_7_133 OUT_133 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_134 (TEMP_7_134 OUT_134 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_135 (TEMP_7_135 OUT_135 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_136 (TEMP_7_136 OUT_136 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_137 (TEMP_7_137 OUT_137 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_138 (TEMP_7_138 OUT_138 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_139 (TEMP_7_139 OUT_139 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_140 (TEMP_7_140 OUT_140 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_141 (TEMP_7_141 OUT_141 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_142 (TEMP_7_142 OUT_142 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_143 (TEMP_7_143 OUT_143 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_144 (TEMP_7_144 OUT_144 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_145 (TEMP_7_145 OUT_145 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_146 (TEMP_7_146 OUT_146 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_147 (TEMP_7_147 OUT_147 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_148 (TEMP_7_148 OUT_148 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_149 (TEMP_7_149 OUT_149 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_150 (TEMP_7_150 OUT_150 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_151 (TEMP_7_151 OUT_151 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_152 (TEMP_7_152 OUT_152 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_153 (TEMP_7_153 OUT_153 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_154 (TEMP_7_154 OUT_154 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_155 (TEMP_7_155 OUT_155 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_156 (TEMP_7_156 OUT_156 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_157 (TEMP_7_157 OUT_157 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_158 (TEMP_7_158 OUT_158 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_159 (TEMP_7_159 OUT_159 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_160 (TEMP_7_160 OUT_160 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_161 (TEMP_7_161 OUT_161 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_162 (TEMP_7_162 OUT_162 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_163 (TEMP_7_163 OUT_163 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_164 (TEMP_7_164 OUT_164 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_165 (TEMP_7_165 OUT_165 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_166 (TEMP_7_166 OUT_166 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_167 (TEMP_7_167 OUT_167 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_168 (TEMP_7_168 OUT_168 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_169 (TEMP_7_169 OUT_169 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_170 (TEMP_7_170 OUT_170 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_171 (TEMP_7_171 OUT_171 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_172 (TEMP_7_172 OUT_172 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_173 (TEMP_7_173 OUT_173 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_174 (TEMP_7_174 OUT_174 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_175 (TEMP_7_175 OUT_175 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_176 (TEMP_7_176 OUT_176 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_177 (TEMP_7_177 OUT_177 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_178 (TEMP_7_178 OUT_178 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_179 (TEMP_7_179 OUT_179 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_180 (TEMP_7_180 OUT_180 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_181 (TEMP_7_181 OUT_181 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_182 (TEMP_7_182 OUT_182 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_183 (TEMP_7_183 OUT_183 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_184 (TEMP_7_184 OUT_184 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_185 (TEMP_7_185 OUT_185 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_186 (TEMP_7_186 OUT_186 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_187 (TEMP_7_187 OUT_187 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_188 (TEMP_7_188 OUT_188 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_189 (TEMP_7_189 OUT_189 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_190 (TEMP_7_190 OUT_190 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_191 (TEMP_7_191 OUT_191 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_192 (TEMP_7_192 OUT_192 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_193 (TEMP_7_193 OUT_193 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_194 (TEMP_7_194 OUT_194 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_195 (TEMP_7_195 OUT_195 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_196 (TEMP_7_196 OUT_196 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_197 (TEMP_7_197 OUT_197 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_198 (TEMP_7_198 OUT_198 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_199 (TEMP_7_199 OUT_199 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_200 (TEMP_7_200 OUT_200 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_201 (TEMP_7_201 OUT_201 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_202 (TEMP_7_202 OUT_202 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_203 (TEMP_7_203 OUT_203 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_204 (TEMP_7_204 OUT_204 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_205 (TEMP_7_205 OUT_205 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_206 (TEMP_7_206 OUT_206 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_207 (TEMP_7_207 OUT_207 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_208 (TEMP_7_208 OUT_208 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_209 (TEMP_7_209 OUT_209 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_210 (TEMP_7_210 OUT_210 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_211 (TEMP_7_211 OUT_211 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_212 (TEMP_7_212 OUT_212 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_213 (TEMP_7_213 OUT_213 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_214 (TEMP_7_214 OUT_214 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_215 (TEMP_7_215 OUT_215 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_216 (TEMP_7_216 OUT_216 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_217 (TEMP_7_217 OUT_217 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_218 (TEMP_7_218 OUT_218 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_219 (TEMP_7_219 OUT_219 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_220 (TEMP_7_220 OUT_220 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_221 (TEMP_7_221 OUT_221 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_222 (TEMP_7_222 OUT_222 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_223 (TEMP_7_223 OUT_223 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_224 (TEMP_7_224 OUT_224 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_225 (TEMP_7_225 OUT_225 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_226 (TEMP_7_226 OUT_226 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_227 (TEMP_7_227 OUT_227 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_228 (TEMP_7_228 OUT_228 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_229 (TEMP_7_229 OUT_229 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_230 (TEMP_7_230 OUT_230 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_231 (TEMP_7_231 OUT_231 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_232 (TEMP_7_232 OUT_232 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_233 (TEMP_7_233 OUT_233 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_234 (TEMP_7_234 OUT_234 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_235 (TEMP_7_235 OUT_235 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_236 (TEMP_7_236 OUT_236 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_237 (TEMP_7_237 OUT_237 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_238 (TEMP_7_238 OUT_238 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_239 (TEMP_7_239 OUT_239 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_240 (TEMP_7_240 OUT_240 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_241 (TEMP_7_241 OUT_241 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_242 (TEMP_7_242 OUT_242 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_243 (TEMP_7_243 OUT_243 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_244 (TEMP_7_244 OUT_244 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_245 (TEMP_7_245 OUT_245 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_246 (TEMP_7_246 OUT_246 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_247 (TEMP_7_247 OUT_247 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_248 (TEMP_7_248 OUT_248 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_249 (TEMP_7_249 OUT_249 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_250 (TEMP_7_250 OUT_250 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_251 (TEMP_7_251 OUT_251 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_252 (TEMP_7_252 OUT_252 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_253 (TEMP_7_253 OUT_253 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_254 (TEMP_7_254 OUT_254 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156
xNOT_7_255 (TEMP_7_255 OUT_255 vdd vss PBulkLine NBulkLine) inverter mult=1.2156156

Vvdd     ( vdd     0 ) vsource dc=1
VvddBulk ( PBulkLine 0 ) vsource dc=1
Vvss     ( vss     0 ) vsource dc=0
VvssBulk ( NBulkLine 0 ) vsource dc=0

Ven (enable 0) vsource type=pwl wave=waveen

Vin0 (IN_0 0) vsource type=pwl wave=wavein_0
Vin1 (IN_1 0) vsource type=pwl wave=wavein_1
Vin2 (IN_2 0) vsource type=pwl wave=wavein_2
Vin3 (IN_3 0) vsource type=pwl wave=wavein_3
Vin4 (IN_4 0) vsource type=pwl wave=wavein_4
Vin5 (IN_5 0) vsource type=pwl wave=wavein_5
Vin6 (IN_6 0) vsource type=pwl wave=wavein_6
Vin7 (IN_7 0) vsource type=pwl wave=wavein_7

// save IN_0 IN_1 IN_2 IN_3 IN_4 IN_5 IN_6 IN_7 enable OUT_0 OUT_1 OUT_2 OUT_3 OUT_4 OUT_5 OUT_6 OUT_7 OUT_8 OUT_9 OUT_10 OUT_11 OUT_12 OUT_13 OUT_14 OUT_15 OUT_16 OUT_17 OUT_18 OUT_19 OUT_20 OUT_21 OUT_22 OUT_23 OUT_24 OUT_25 OUT_26 OUT_27 OUT_28 OUT_29 OUT_30 OUT_31 OUT_32 OUT_33 OUT_34 OUT_35 OUT_36 OUT_37 OUT_38 OUT_39 OUT_40 OUT_41 OUT_42 OUT_43 OUT_44 OUT_45 OUT_46 OUT_47 OUT_48 OUT_49 OUT_50 OUT_51 OUT_52 OUT_53 OUT_54 OUT_55 OUT_56 OUT_57 OUT_58 OUT_59 OUT_60 OUT_61 OUT_62 OUT_63 OUT_64 OUT_65 OUT_66 OUT_67 OUT_68 OUT_69 OUT_70 OUT_71 OUT_72 OUT_73 OUT_74 OUT_75 OUT_76 OUT_77 OUT_78 OUT_79 OUT_80 OUT_81 OUT_82 OUT_83 OUT_84 OUT_85 OUT_86 OUT_87 OUT_88 OUT_89 OUT_90 OUT_91 OUT_92 OUT_93 OUT_94 OUT_95 OUT_96 OUT_97 OUT_98 OUT_99 OUT_100 OUT_101 OUT_102 OUT_103 OUT_104 OUT_105 OUT_106 OUT_107 OUT_108 OUT_109 OUT_110 OUT_111 OUT_112 OUT_113 OUT_114 OUT_115 OUT_116 OUT_117 OUT_118 OUT_119 OUT_120 OUT_121 OUT_122 OUT_123 OUT_124 OUT_125 OUT_126 OUT_127 OUT_128 OUT_129 OUT_130 OUT_131 OUT_132 OUT_133 OUT_134 OUT_135 OUT_136 OUT_137 OUT_138 OUT_139 OUT_140 OUT_141 OUT_142 OUT_143 OUT_144 OUT_145 OUT_146 OUT_147 OUT_148 OUT_149 OUT_150 OUT_151 OUT_152 OUT_153 OUT_154 OUT_155 OUT_156 OUT_157 OUT_158 OUT_159 OUT_160 OUT_161 OUT_162 OUT_163 OUT_164 OUT_165 OUT_166 OUT_167 OUT_168 OUT_169 OUT_170 OUT_171 OUT_172 OUT_173 OUT_174 OUT_175 OUT_176 OUT_177 OUT_178 OUT_179 OUT_180 OUT_181 OUT_182 OUT_183 OUT_184 OUT_185 OUT_186 OUT_187 OUT_188 OUT_189 OUT_190 OUT_191 OUT_192 OUT_193 OUT_194 OUT_195 OUT_196 OUT_197 OUT_198 OUT_199 OUT_200 OUT_201 OUT_202 OUT_203 OUT_204 OUT_205 OUT_206 OUT_207 OUT_208 OUT_209 OUT_210 OUT_211 OUT_212 OUT_213 OUT_214 OUT_215 OUT_216 OUT_217 OUT_218 OUT_219 OUT_220 OUT_221 OUT_222 OUT_223 OUT_224 OUT_225 OUT_226 OUT_227 OUT_228 OUT_229 OUT_230 OUT_231 OUT_232 OUT_233 OUT_234 OUT_235 OUT_236 OUT_237 OUT_238 OUT_239 OUT_240 OUT_241 OUT_242 OUT_243 OUT_244 OUT_245 OUT_246 OUT_247 OUT_248 OUT_249 OUT_250 OUT_251 OUT_252 OUT_253 OUT_254 OUT_255 Vvdd:currents

mymc montecarlo
+ donominal=no variations=mismatch
+ seed=1234
+ numruns=numberofruns
+ firstrun=1
+ saveprocessparams=yes
+ savefamilyplots= yes {
mytran tran stop=simlength
}

option1 options rawfmt = psfascii
