.hdl "../verilog/RME_QMMODEL_ANALYTICAL/HOURGLASS.va"

simulator lang = spectre

subckt memristor ( node1  node2 )

Xrme node1 node2 HOURGLASS
+ V0        = -0.05
+ omega_x   = 9e+14
+ omega_y_0 = 9e+15
+
+ N_TR = 30
+ N_BR = 2
+
+ initial_n_CO = 5
+ initial_n_TR = 30
+ initial_n_BR = 2
+
+ Ea           = 1.68231e-19
+ Tambient     = 297
+ Rthermal     = 1.2e+10
+ c_thermal    = 0.0075
+ alpha_0      = 0.03
+ f0           = 1e+13
+ m_n          = 2
+
+ enable_stochastics       = 1
+ initial_seed             = 253
+ flux_limit               = 8e+12
+ progressPrintStep        = 10e-9//2.50275e-10
+ time_step_bound          = 10e-12 //1.251375e-13
+ verbose_logfile          = 0
+ Nmax                     = 50

ends memristor
