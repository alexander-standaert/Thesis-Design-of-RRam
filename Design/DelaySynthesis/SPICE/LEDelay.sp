simulator lang=spice
.lib '../../technology_models/tech_wrapper.lib' tt
.OPTIONS METHOD=trap
.TEMP 30

simulator lang=spectre
include "../../technology_models/monte_carlo_models.scs"
include "../../ArchitectureDesign/SPICE/CMOSlogic.scs"
parameters enableMismatch=0
ana tran step=1e-12 stop=2e-08
option1 options rawfmt = psfascii
option2 options dc_pivot_check = yes

cap info what=captab where=file file="%LEDcap"

vin in vss vsource type=pwl wave=[0 1 1e-09 1 1.001e-09 0]
vgnd vss 0 vsource type=dc dc=0
vvdd vdd 0 vsource type=dc dc=1
parameters PWmin = 100n                         //MinimalTransistorWidth
parameters PLmin = 45n                          //MinimalTransistorLenght

subckt buffer_INVNOR_eight (vdd vss NBulkLine PBulkLine node_0 node_2)
xNot_8_1 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_8_2 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=4
ends buffer_INVNOR_eight

subckt buffer_INVNOR_sixteen (vdd vss NBulkLine PBulkLine node_0 node_2)
xNot_16_2 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=4
xNot_16_3 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=16
ends buffer_INVNOR_sixteen

subckt buffer_INVNOR_thirtytwo (vdd vss NBulkLine PBulkLine node_0 node_2)
xNot_32_2 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=4
xNot_32_3 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=16
ends buffer_INVNOR_thirtytwo

subckt buffer_INVNOR_sixtyfour (vdd vss NBulkLine PBulkLine node_0 node_4)
xNot_64_1 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_64_2 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=4
xNot_64_3 (node_2 node_3 vdd vss PBulkLine NBulkLine) inverter mult=16
xNot_64_4 (node_3 node_4 vdd vss PBulkLine NBulkLine) inverter mult=64
ends buffer_INVNOR_sixtyfour

subckt buffer_INVNOR_onehundredtwentyeight (vdd vss NBulkLine PBulkLine node_0 node_4)
xNot_128_1 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_128_2 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=4
xNot_128_3 (node_2 node_3 vdd vss PBulkLine NBulkLine) inverter mult=16
xNot_128_4 (node_3 node_4 vdd vss PBulkLine NBulkLine) inverter mult=64
ends buffer_INVNOR_onehundredtwentyeight

subckt buffer_INVNOR_twohundredfiftysix (vdd vss NBulkLine PBulkLine node_0 node_4)
xNot_256_2 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=4
xNot_256_3 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=16
xNot_256_4 (node_2 node_3 vdd vss PBulkLine NBulkLine) inverter mult=64
xNot_256_5 (node_3 node_4 vdd vss PBulkLine NBulkLine) inverter mult=256
ends buffer_INVNOR_twohundredfiftysix

subckt buffer_INVNOR_fivehundredandtwelve (vdd vss NBulkLine PBulkLine node_0 node_4)
xNot_512_2 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=4
xNot_512_3 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=16
xNot_512_4 (node_2 node_3 vdd vss PBulkLine NBulkLine) inverter mult=64
xNot_512_5 (node_3 node_4 vdd vss PBulkLine NBulkLine) inverter mult=256
ends buffer_INVNOR_fivehundredandtwelve

subckt buffer_INVNOR_onethousandtwentyfour (vdd vss NBulkLine PBulkLine node_0 node_6)
xNot_1024_1 (node_0 node_1 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_1024_2 (node_1 node_2 vdd vss PBulkLine NBulkLine) inverter mult=4
xNot_1024_3 (node_2 node_3 vdd vss PBulkLine NBulkLine) inverter mult=16
xNot_1024_4 (node_3 node_4 vdd vss PBulkLine NBulkLine) inverter mult=64
xNot_1024_5 (node_4 node_5 vdd vss PBulkLine NBulkLine) inverter mult=256
xNot_1024_6 (node_5 node_6 vdd vss PBulkLine NBulkLine) inverter mult=1024
ends buffer_INVNOR_onethousandtwentyfour

subckt buffer_sized (vdd vss NBulkLine PBulkLine in out_8 out_16 out_32 out_64 out_128 out_256 out_512 out_1024)

xbuffer_8 (vdd vss vss vdd in out_8) buffer_INVNOR_eight
//nor_8_1 (out_8 vdd norout8_1 vdd vss PBulkLine NBulkLine) twonor
//nor_8_2 (out_8 vdd norout8_2 vdd vss PBulkLine NBulkLine) twonor
//nor_8_3 (out_8 vdd norout8_3 vdd vss PBulkLine NBulkLine) twonor
//nor_8_4 (out_8 vdd norout8_4 vdd vss PBulkLine NBulkLine) twonor
//nor_8_5 (out_8 vdd norout8_5 vdd vss PBulkLine NBulkLine) twonor
//nor_8_6 (out_8 vdd norout8_6 vdd vss PBulkLine NBulkLine) twonor
//nor_8_7 (out_8 vdd norout8_7 vdd vss PBulkLine NBulkLine) twonor
//nor_8_8 (out_8 vdd norout8_8 vdd vss PBulkLine NBulkLine) twonor
cPar_8 out_8 vss capacitor c=1.44e-15
xbuffer_16 (vdd vss vss vdd in out_16) buffer_INVNOR_sixteen
//nor_16_1 (out_16 vdd norout16_1 vdd vss PBulkLine NBulkLine) twonor
//nor_16_2 (out_16 vdd norout16_2 vdd vss PBulkLine NBulkLine) twonor
//nor_16_3 (out_16 vdd norout16_3 vdd vss PBulkLine NBulkLine) twonor
//nor_16_4 (out_16 vdd norout16_4 vdd vss PBulkLine NBulkLine) twonor
//nor_16_5 (out_16 vdd norout16_5 vdd vss PBulkLine NBulkLine) twonor
//nor_16_6 (out_16 vdd norout16_6 vdd vss PBulkLine NBulkLine) twonor
//nor_16_7 (out_16 vdd norout16_7 vdd vss PBulkLine NBulkLine) twonor
//nor_16_8 (out_16 vdd norout16_8 vdd vss PBulkLine NBulkLine) twonor
//nor_16_9 (out_16 vdd norout16_9 vdd vss PBulkLine NBulkLine) twonor
//nor_16_10 (out_16 vdd norout16_10 vdd vss PBulkLine NBulkLine) twonor
//nor_16_11 (out_16 vdd norout16_11 vdd vss PBulkLine NBulkLine) twonor
//nor_16_12 (out_16 vdd norout16_12 vdd vss PBulkLine NBulkLine) twonor
//nor_16_13 (out_16 vdd norout16_13 vdd vss PBulkLine NBulkLine) twonor
//nor_16_14 (out_16 vdd norout16_14 vdd vss PBulkLine NBulkLine) twonor
//nor_16_15 (out_16 vdd norout16_15 vdd vss PBulkLine NBulkLine) twonor
//nor_16_16 (out_16 vdd norout16_16 vdd vss PBulkLine NBulkLine) twonor
cPar_16 out_16 vss capacitor c=2.88e-15
xbuffer_32 (vdd vss vss vdd in out_32) buffer_INVNOR_thirtytwo
//nor_32_1 (out_32 vdd norout32_1 vdd vss PBulkLine NBulkLine) twonor
//nor_32_2 (out_32 vdd norout32_2 vdd vss PBulkLine NBulkLine) twonor
//nor_32_3 (out_32 vdd norout32_3 vdd vss PBulkLine NBulkLine) twonor
//nor_32_4 (out_32 vdd norout32_4 vdd vss PBulkLine NBulkLine) twonor
//nor_32_5 (out_32 vdd norout32_5 vdd vss PBulkLine NBulkLine) twonor
//nor_32_6 (out_32 vdd norout32_6 vdd vss PBulkLine NBulkLine) twonor
//nor_32_7 (out_32 vdd norout32_7 vdd vss PBulkLine NBulkLine) twonor
//nor_32_8 (out_32 vdd norout32_8 vdd vss PBulkLine NBulkLine) twonor
//nor_32_9 (out_32 vdd norout32_9 vdd vss PBulkLine NBulkLine) twonor
//nor_32_10 (out_32 vdd norout32_10 vdd vss PBulkLine NBulkLine) twonor
//nor_32_11 (out_32 vdd norout32_11 vdd vss PBulkLine NBulkLine) twonor
//nor_32_12 (out_32 vdd norout32_12 vdd vss PBulkLine NBulkLine) twonor
//nor_32_13 (out_32 vdd norout32_13 vdd vss PBulkLine NBulkLine) twonor
//nor_32_14 (out_32 vdd norout32_14 vdd vss PBulkLine NBulkLine) twonor
//nor_32_15 (out_32 vdd norout32_15 vdd vss PBulkLine NBulkLine) twonor
//nor_32_16 (out_32 vdd norout32_16 vdd vss PBulkLine NBulkLine) twonor
//nor_32_17 (out_32 vdd norout32_17 vdd vss PBulkLine NBulkLine) twonor
//nor_32_18 (out_32 vdd norout32_18 vdd vss PBulkLine NBulkLine) twonor
//nor_32_19 (out_32 vdd norout32_19 vdd vss PBulkLine NBulkLine) twonor
//nor_32_20 (out_32 vdd norout32_20 vdd vss PBulkLine NBulkLine) twonor
//nor_32_21 (out_32 vdd norout32_21 vdd vss PBulkLine NBulkLine) twonor
//nor_32_22 (out_32 vdd norout32_22 vdd vss PBulkLine NBulkLine) twonor
//nor_32_23 (out_32 vdd norout32_23 vdd vss PBulkLine NBulkLine) twonor
//nor_32_24 (out_32 vdd norout32_24 vdd vss PBulkLine NBulkLine) twonor
//nor_32_25 (out_32 vdd norout32_25 vdd vss PBulkLine NBulkLine) twonor
//nor_32_26 (out_32 vdd norout32_26 vdd vss PBulkLine NBulkLine) twonor
//nor_32_27 (out_32 vdd norout32_27 vdd vss PBulkLine NBulkLine) twonor
//nor_32_28 (out_32 vdd norout32_28 vdd vss PBulkLine NBulkLine) twonor
//nor_32_29 (out_32 vdd norout32_29 vdd vss PBulkLine NBulkLine) twonor
//nor_32_30 (out_32 vdd norout32_30 vdd vss PBulkLine NBulkLine) twonor
//nor_32_31 (out_32 vdd norout32_31 vdd vss PBulkLine NBulkLine) twonor
//nor_32_32 (out_32 vdd norout32_32 vdd vss PBulkLine NBulkLine) twonor
cPar_32 out_32 vss capacitor c=5.76e-15
xbuffer_64 (vdd vss vss vdd in out_64) buffer_INVNOR_sixtyfour
//nor_64_1 (out_64 vdd norout64_1 vdd vss PBulkLine NBulkLine) twonor
//nor_64_2 (out_64 vdd norout64_2 vdd vss PBulkLine NBulkLine) twonor
//nor_64_3 (out_64 vdd norout64_3 vdd vss PBulkLine NBulkLine) twonor
//nor_64_4 (out_64 vdd norout64_4 vdd vss PBulkLine NBulkLine) twonor
//nor_64_5 (out_64 vdd norout64_5 vdd vss PBulkLine NBulkLine) twonor
//nor_64_6 (out_64 vdd norout64_6 vdd vss PBulkLine NBulkLine) twonor
//nor_64_7 (out_64 vdd norout64_7 vdd vss PBulkLine NBulkLine) twonor
//nor_64_8 (out_64 vdd norout64_8 vdd vss PBulkLine NBulkLine) twonor
//nor_64_9 (out_64 vdd norout64_9 vdd vss PBulkLine NBulkLine) twonor
//nor_64_10 (out_64 vdd norout64_10 vdd vss PBulkLine NBulkLine) twonor
//nor_64_11 (out_64 vdd norout64_11 vdd vss PBulkLine NBulkLine) twonor
//nor_64_12 (out_64 vdd norout64_12 vdd vss PBulkLine NBulkLine) twonor
//nor_64_13 (out_64 vdd norout64_13 vdd vss PBulkLine NBulkLine) twonor
//nor_64_14 (out_64 vdd norout64_14 vdd vss PBulkLine NBulkLine) twonor
//nor_64_15 (out_64 vdd norout64_15 vdd vss PBulkLine NBulkLine) twonor
//nor_64_16 (out_64 vdd norout64_16 vdd vss PBulkLine NBulkLine) twonor
//nor_64_17 (out_64 vdd norout64_17 vdd vss PBulkLine NBulkLine) twonor
//nor_64_18 (out_64 vdd norout64_18 vdd vss PBulkLine NBulkLine) twonor
//nor_64_19 (out_64 vdd norout64_19 vdd vss PBulkLine NBulkLine) twonor
//nor_64_20 (out_64 vdd norout64_20 vdd vss PBulkLine NBulkLine) twonor
//nor_64_21 (out_64 vdd norout64_21 vdd vss PBulkLine NBulkLine) twonor
//nor_64_22 (out_64 vdd norout64_22 vdd vss PBulkLine NBulkLine) twonor
//nor_64_23 (out_64 vdd norout64_23 vdd vss PBulkLine NBulkLine) twonor
//nor_64_24 (out_64 vdd norout64_24 vdd vss PBulkLine NBulkLine) twonor
//nor_64_25 (out_64 vdd norout64_25 vdd vss PBulkLine NBulkLine) twonor
//nor_64_26 (out_64 vdd norout64_26 vdd vss PBulkLine NBulkLine) twonor
//nor_64_27 (out_64 vdd norout64_27 vdd vss PBulkLine NBulkLine) twonor
//nor_64_28 (out_64 vdd norout64_28 vdd vss PBulkLine NBulkLine) twonor
//nor_64_29 (out_64 vdd norout64_29 vdd vss PBulkLine NBulkLine) twonor
//nor_64_30 (out_64 vdd norout64_30 vdd vss PBulkLine NBulkLine) twonor
//nor_64_31 (out_64 vdd norout64_31 vdd vss PBulkLine NBulkLine) twonor
//nor_64_32 (out_64 vdd norout64_32 vdd vss PBulkLine NBulkLine) twonor
//nor_64_33 (out_64 vdd norout64_33 vdd vss PBulkLine NBulkLine) twonor
//nor_64_34 (out_64 vdd norout64_34 vdd vss PBulkLine NBulkLine) twonor
//nor_64_35 (out_64 vdd norout64_35 vdd vss PBulkLine NBulkLine) twonor
//nor_64_36 (out_64 vdd norout64_36 vdd vss PBulkLine NBulkLine) twonor
//nor_64_37 (out_64 vdd norout64_37 vdd vss PBulkLine NBulkLine) twonor
//nor_64_38 (out_64 vdd norout64_38 vdd vss PBulkLine NBulkLine) twonor
//nor_64_39 (out_64 vdd norout64_39 vdd vss PBulkLine NBulkLine) twonor
//nor_64_40 (out_64 vdd norout64_40 vdd vss PBulkLine NBulkLine) twonor
//nor_64_41 (out_64 vdd norout64_41 vdd vss PBulkLine NBulkLine) twonor
//nor_64_42 (out_64 vdd norout64_42 vdd vss PBulkLine NBulkLine) twonor
//nor_64_43 (out_64 vdd norout64_43 vdd vss PBulkLine NBulkLine) twonor
//nor_64_44 (out_64 vdd norout64_44 vdd vss PBulkLine NBulkLine) twonor
//nor_64_45 (out_64 vdd norout64_45 vdd vss PBulkLine NBulkLine) twonor
//nor_64_46 (out_64 vdd norout64_46 vdd vss PBulkLine NBulkLine) twonor
//nor_64_47 (out_64 vdd norout64_47 vdd vss PBulkLine NBulkLine) twonor
//nor_64_48 (out_64 vdd norout64_48 vdd vss PBulkLine NBulkLine) twonor
//nor_64_49 (out_64 vdd norout64_49 vdd vss PBulkLine NBulkLine) twonor
//nor_64_50 (out_64 vdd norout64_50 vdd vss PBulkLine NBulkLine) twonor
//nor_64_51 (out_64 vdd norout64_51 vdd vss PBulkLine NBulkLine) twonor
//nor_64_52 (out_64 vdd norout64_52 vdd vss PBulkLine NBulkLine) twonor
//nor_64_53 (out_64 vdd norout64_53 vdd vss PBulkLine NBulkLine) twonor
//nor_64_54 (out_64 vdd norout64_54 vdd vss PBulkLine NBulkLine) twonor
//nor_64_55 (out_64 vdd norout64_55 vdd vss PBulkLine NBulkLine) twonor
//nor_64_56 (out_64 vdd norout64_56 vdd vss PBulkLine NBulkLine) twonor
//nor_64_57 (out_64 vdd norout64_57 vdd vss PBulkLine NBulkLine) twonor
//nor_64_58 (out_64 vdd norout64_58 vdd vss PBulkLine NBulkLine) twonor
//nor_64_59 (out_64 vdd norout64_59 vdd vss PBulkLine NBulkLine) twonor
//nor_64_60 (out_64 vdd norout64_60 vdd vss PBulkLine NBulkLine) twonor
//nor_64_61 (out_64 vdd norout64_61 vdd vss PBulkLine NBulkLine) twonor
//nor_64_62 (out_64 vdd norout64_62 vdd vss PBulkLine NBulkLine) twonor
//nor_64_63 (out_64 vdd norout64_63 vdd vss PBulkLine NBulkLine) twonor
//nor_64_64 (out_64 vdd norout64_64 vdd vss PBulkLine NBulkLine) twonor
cPar_64 out_64 vss capacitor c=1.152e-14
xbuffer_128 (vdd vss vss vdd in out_128) buffer_INVNOR_onehundredtwentyeight
//nor_128_1 (out_128 vdd norout128_1 vdd vss PBulkLine NBulkLine) twonor
//nor_128_2 (out_128 vdd norout128_2 vdd vss PBulkLine NBulkLine) twonor
//nor_128_3 (out_128 vdd norout128_3 vdd vss PBulkLine NBulkLine) twonor
//nor_128_4 (out_128 vdd norout128_4 vdd vss PBulkLine NBulkLine) twonor
//nor_128_5 (out_128 vdd norout128_5 vdd vss PBulkLine NBulkLine) twonor
//nor_128_6 (out_128 vdd norout128_6 vdd vss PBulkLine NBulkLine) twonor
//nor_128_7 (out_128 vdd norout128_7 vdd vss PBulkLine NBulkLine) twonor
//nor_128_8 (out_128 vdd norout128_8 vdd vss PBulkLine NBulkLine) twonor
//nor_128_9 (out_128 vdd norout128_9 vdd vss PBulkLine NBulkLine) twonor
//nor_128_10 (out_128 vdd norout128_10 vdd vss PBulkLine NBulkLine) twonor
//nor_128_11 (out_128 vdd norout128_11 vdd vss PBulkLine NBulkLine) twonor
//nor_128_12 (out_128 vdd norout128_12 vdd vss PBulkLine NBulkLine) twonor
//nor_128_13 (out_128 vdd norout128_13 vdd vss PBulkLine NBulkLine) twonor
//nor_128_14 (out_128 vdd norout128_14 vdd vss PBulkLine NBulkLine) twonor
//nor_128_15 (out_128 vdd norout128_15 vdd vss PBulkLine NBulkLine) twonor
//nor_128_16 (out_128 vdd norout128_16 vdd vss PBulkLine NBulkLine) twonor
//nor_128_17 (out_128 vdd norout128_17 vdd vss PBulkLine NBulkLine) twonor
//nor_128_18 (out_128 vdd norout128_18 vdd vss PBulkLine NBulkLine) twonor
//nor_128_19 (out_128 vdd norout128_19 vdd vss PBulkLine NBulkLine) twonor
//nor_128_20 (out_128 vdd norout128_20 vdd vss PBulkLine NBulkLine) twonor
//nor_128_21 (out_128 vdd norout128_21 vdd vss PBulkLine NBulkLine) twonor
//nor_128_22 (out_128 vdd norout128_22 vdd vss PBulkLine NBulkLine) twonor
//nor_128_23 (out_128 vdd norout128_23 vdd vss PBulkLine NBulkLine) twonor
//nor_128_24 (out_128 vdd norout128_24 vdd vss PBulkLine NBulkLine) twonor
//nor_128_25 (out_128 vdd norout128_25 vdd vss PBulkLine NBulkLine) twonor
//nor_128_26 (out_128 vdd norout128_26 vdd vss PBulkLine NBulkLine) twonor
//nor_128_27 (out_128 vdd norout128_27 vdd vss PBulkLine NBulkLine) twonor
//nor_128_28 (out_128 vdd norout128_28 vdd vss PBulkLine NBulkLine) twonor
//nor_128_29 (out_128 vdd norout128_29 vdd vss PBulkLine NBulkLine) twonor
//nor_128_30 (out_128 vdd norout128_30 vdd vss PBulkLine NBulkLine) twonor
//nor_128_31 (out_128 vdd norout128_31 vdd vss PBulkLine NBulkLine) twonor
//nor_128_32 (out_128 vdd norout128_32 vdd vss PBulkLine NBulkLine) twonor
//nor_128_33 (out_128 vdd norout128_33 vdd vss PBulkLine NBulkLine) twonor
//nor_128_34 (out_128 vdd norout128_34 vdd vss PBulkLine NBulkLine) twonor
//nor_128_35 (out_128 vdd norout128_35 vdd vss PBulkLine NBulkLine) twonor
//nor_128_36 (out_128 vdd norout128_36 vdd vss PBulkLine NBulkLine) twonor
//nor_128_37 (out_128 vdd norout128_37 vdd vss PBulkLine NBulkLine) twonor
//nor_128_38 (out_128 vdd norout128_38 vdd vss PBulkLine NBulkLine) twonor
//nor_128_39 (out_128 vdd norout128_39 vdd vss PBulkLine NBulkLine) twonor
//nor_128_40 (out_128 vdd norout128_40 vdd vss PBulkLine NBulkLine) twonor
//nor_128_41 (out_128 vdd norout128_41 vdd vss PBulkLine NBulkLine) twonor
//nor_128_42 (out_128 vdd norout128_42 vdd vss PBulkLine NBulkLine) twonor
//nor_128_43 (out_128 vdd norout128_43 vdd vss PBulkLine NBulkLine) twonor
//nor_128_44 (out_128 vdd norout128_44 vdd vss PBulkLine NBulkLine) twonor
//nor_128_45 (out_128 vdd norout128_45 vdd vss PBulkLine NBulkLine) twonor
//nor_128_46 (out_128 vdd norout128_46 vdd vss PBulkLine NBulkLine) twonor
//nor_128_47 (out_128 vdd norout128_47 vdd vss PBulkLine NBulkLine) twonor
//nor_128_48 (out_128 vdd norout128_48 vdd vss PBulkLine NBulkLine) twonor
//nor_128_49 (out_128 vdd norout128_49 vdd vss PBulkLine NBulkLine) twonor
//nor_128_50 (out_128 vdd norout128_50 vdd vss PBulkLine NBulkLine) twonor
//nor_128_51 (out_128 vdd norout128_51 vdd vss PBulkLine NBulkLine) twonor
//nor_128_52 (out_128 vdd norout128_52 vdd vss PBulkLine NBulkLine) twonor
//nor_128_53 (out_128 vdd norout128_53 vdd vss PBulkLine NBulkLine) twonor
//nor_128_54 (out_128 vdd norout128_54 vdd vss PBulkLine NBulkLine) twonor
//nor_128_55 (out_128 vdd norout128_55 vdd vss PBulkLine NBulkLine) twonor
//nor_128_56 (out_128 vdd norout128_56 vdd vss PBulkLine NBulkLine) twonor
//nor_128_57 (out_128 vdd norout128_57 vdd vss PBulkLine NBulkLine) twonor
//nor_128_58 (out_128 vdd norout128_58 vdd vss PBulkLine NBulkLine) twonor
//nor_128_59 (out_128 vdd norout128_59 vdd vss PBulkLine NBulkLine) twonor
//nor_128_60 (out_128 vdd norout128_60 vdd vss PBulkLine NBulkLine) twonor
//nor_128_61 (out_128 vdd norout128_61 vdd vss PBulkLine NBulkLine) twonor
//nor_128_62 (out_128 vdd norout128_62 vdd vss PBulkLine NBulkLine) twonor
//nor_128_63 (out_128 vdd norout128_63 vdd vss PBulkLine NBulkLine) twonor
//nor_128_64 (out_128 vdd norout128_64 vdd vss PBulkLine NBulkLine) twonor
//nor_128_65 (out_128 vdd norout128_65 vdd vss PBulkLine NBulkLine) twonor
//nor_128_66 (out_128 vdd norout128_66 vdd vss PBulkLine NBulkLine) twonor
//nor_128_67 (out_128 vdd norout128_67 vdd vss PBulkLine NBulkLine) twonor
//nor_128_68 (out_128 vdd norout128_68 vdd vss PBulkLine NBulkLine) twonor
//nor_128_69 (out_128 vdd norout128_69 vdd vss PBulkLine NBulkLine) twonor
//nor_128_70 (out_128 vdd norout128_70 vdd vss PBulkLine NBulkLine) twonor
//nor_128_71 (out_128 vdd norout128_71 vdd vss PBulkLine NBulkLine) twonor
//nor_128_72 (out_128 vdd norout128_72 vdd vss PBulkLine NBulkLine) twonor
//nor_128_73 (out_128 vdd norout128_73 vdd vss PBulkLine NBulkLine) twonor
//nor_128_74 (out_128 vdd norout128_74 vdd vss PBulkLine NBulkLine) twonor
//nor_128_75 (out_128 vdd norout128_75 vdd vss PBulkLine NBulkLine) twonor
//nor_128_76 (out_128 vdd norout128_76 vdd vss PBulkLine NBulkLine) twonor
//nor_128_77 (out_128 vdd norout128_77 vdd vss PBulkLine NBulkLine) twonor
//nor_128_78 (out_128 vdd norout128_78 vdd vss PBulkLine NBulkLine) twonor
//nor_128_79 (out_128 vdd norout128_79 vdd vss PBulkLine NBulkLine) twonor
//nor_128_80 (out_128 vdd norout128_80 vdd vss PBulkLine NBulkLine) twonor
//nor_128_81 (out_128 vdd norout128_81 vdd vss PBulkLine NBulkLine) twonor
//nor_128_82 (out_128 vdd norout128_82 vdd vss PBulkLine NBulkLine) twonor
//nor_128_83 (out_128 vdd norout128_83 vdd vss PBulkLine NBulkLine) twonor
//nor_128_84 (out_128 vdd norout128_84 vdd vss PBulkLine NBulkLine) twonor
//nor_128_85 (out_128 vdd norout128_85 vdd vss PBulkLine NBulkLine) twonor
//nor_128_86 (out_128 vdd norout128_86 vdd vss PBulkLine NBulkLine) twonor
//nor_128_87 (out_128 vdd norout128_87 vdd vss PBulkLine NBulkLine) twonor
//nor_128_88 (out_128 vdd norout128_88 vdd vss PBulkLine NBulkLine) twonor
//nor_128_89 (out_128 vdd norout128_89 vdd vss PBulkLine NBulkLine) twonor
//nor_128_90 (out_128 vdd norout128_90 vdd vss PBulkLine NBulkLine) twonor
//nor_128_91 (out_128 vdd norout128_91 vdd vss PBulkLine NBulkLine) twonor
//nor_128_92 (out_128 vdd norout128_92 vdd vss PBulkLine NBulkLine) twonor
//nor_128_93 (out_128 vdd norout128_93 vdd vss PBulkLine NBulkLine) twonor
//nor_128_94 (out_128 vdd norout128_94 vdd vss PBulkLine NBulkLine) twonor
//nor_128_95 (out_128 vdd norout128_95 vdd vss PBulkLine NBulkLine) twonor
//nor_128_96 (out_128 vdd norout128_96 vdd vss PBulkLine NBulkLine) twonor
//nor_128_97 (out_128 vdd norout128_97 vdd vss PBulkLine NBulkLine) twonor
//nor_128_98 (out_128 vdd norout128_98 vdd vss PBulkLine NBulkLine) twonor
//nor_128_99 (out_128 vdd norout128_99 vdd vss PBulkLine NBulkLine) twonor
//nor_128_100 (out_128 vdd norout128_100 vdd vss PBulkLine NBulkLine) twonor
//nor_128_101 (out_128 vdd norout128_101 vdd vss PBulkLine NBulkLine) twonor
//nor_128_102 (out_128 vdd norout128_102 vdd vss PBulkLine NBulkLine) twonor
//nor_128_103 (out_128 vdd norout128_103 vdd vss PBulkLine NBulkLine) twonor
//nor_128_104 (out_128 vdd norout128_104 vdd vss PBulkLine NBulkLine) twonor
//nor_128_105 (out_128 vdd norout128_105 vdd vss PBulkLine NBulkLine) twonor
//nor_128_106 (out_128 vdd norout128_106 vdd vss PBulkLine NBulkLine) twonor
//nor_128_107 (out_128 vdd norout128_107 vdd vss PBulkLine NBulkLine) twonor
//nor_128_108 (out_128 vdd norout128_108 vdd vss PBulkLine NBulkLine) twonor
//nor_128_109 (out_128 vdd norout128_109 vdd vss PBulkLine NBulkLine) twonor
//nor_128_110 (out_128 vdd norout128_110 vdd vss PBulkLine NBulkLine) twonor
//nor_128_111 (out_128 vdd norout128_111 vdd vss PBulkLine NBulkLine) twonor
//nor_128_112 (out_128 vdd norout128_112 vdd vss PBulkLine NBulkLine) twonor
//nor_128_113 (out_128 vdd norout128_113 vdd vss PBulkLine NBulkLine) twonor
//nor_128_114 (out_128 vdd norout128_114 vdd vss PBulkLine NBulkLine) twonor
//nor_128_115 (out_128 vdd norout128_115 vdd vss PBulkLine NBulkLine) twonor
//nor_128_116 (out_128 vdd norout128_116 vdd vss PBulkLine NBulkLine) twonor
//nor_128_117 (out_128 vdd norout128_117 vdd vss PBulkLine NBulkLine) twonor
//nor_128_118 (out_128 vdd norout128_118 vdd vss PBulkLine NBulkLine) twonor
//nor_128_119 (out_128 vdd norout128_119 vdd vss PBulkLine NBulkLine) twonor
//nor_128_120 (out_128 vdd norout128_120 vdd vss PBulkLine NBulkLine) twonor
//nor_128_121 (out_128 vdd norout128_121 vdd vss PBulkLine NBulkLine) twonor
//nor_128_122 (out_128 vdd norout128_122 vdd vss PBulkLine NBulkLine) twonor
//nor_128_123 (out_128 vdd norout128_123 vdd vss PBulkLine NBulkLine) twonor
//nor_128_124 (out_128 vdd norout128_124 vdd vss PBulkLine NBulkLine) twonor
//nor_128_125 (out_128 vdd norout128_125 vdd vss PBulkLine NBulkLine) twonor
//nor_128_126 (out_128 vdd norout128_126 vdd vss PBulkLine NBulkLine) twonor
//nor_128_127 (out_128 vdd norout128_127 vdd vss PBulkLine NBulkLine) twonor
//nor_128_128 (out_128 vdd norout128_128 vdd vss PBulkLine NBulkLine) twonor
cPar_128 out_128 vss capacitor c=2.304e-14
xbuffer_256 (vdd vss vss vdd in out_256) buffer_INVNOR_twohundredfiftysix
//nor_256_1 (out_256 vdd norout256_1 vdd vss PBulkLine NBulkLine) twonor
//nor_256_2 (out_256 vdd norout256_2 vdd vss PBulkLine NBulkLine) twonor
//nor_256_3 (out_256 vdd norout256_3 vdd vss PBulkLine NBulkLine) twonor
//nor_256_4 (out_256 vdd norout256_4 vdd vss PBulkLine NBulkLine) twonor
//nor_256_5 (out_256 vdd norout256_5 vdd vss PBulkLine NBulkLine) twonor
//nor_256_6 (out_256 vdd norout256_6 vdd vss PBulkLine NBulkLine) twonor
//nor_256_7 (out_256 vdd norout256_7 vdd vss PBulkLine NBulkLine) twonor
//nor_256_8 (out_256 vdd norout256_8 vdd vss PBulkLine NBulkLine) twonor
//nor_256_9 (out_256 vdd norout256_9 vdd vss PBulkLine NBulkLine) twonor
//nor_256_10 (out_256 vdd norout256_10 vdd vss PBulkLine NBulkLine) twonor
//nor_256_11 (out_256 vdd norout256_11 vdd vss PBulkLine NBulkLine) twonor
//nor_256_12 (out_256 vdd norout256_12 vdd vss PBulkLine NBulkLine) twonor
//nor_256_13 (out_256 vdd norout256_13 vdd vss PBulkLine NBulkLine) twonor
//nor_256_14 (out_256 vdd norout256_14 vdd vss PBulkLine NBulkLine) twonor
//nor_256_15 (out_256 vdd norout256_15 vdd vss PBulkLine NBulkLine) twonor
//nor_256_16 (out_256 vdd norout256_16 vdd vss PBulkLine NBulkLine) twonor
//nor_256_17 (out_256 vdd norout256_17 vdd vss PBulkLine NBulkLine) twonor
//nor_256_18 (out_256 vdd norout256_18 vdd vss PBulkLine NBulkLine) twonor
//nor_256_19 (out_256 vdd norout256_19 vdd vss PBulkLine NBulkLine) twonor
//nor_256_20 (out_256 vdd norout256_20 vdd vss PBulkLine NBulkLine) twonor
//nor_256_21 (out_256 vdd norout256_21 vdd vss PBulkLine NBulkLine) twonor
//nor_256_22 (out_256 vdd norout256_22 vdd vss PBulkLine NBulkLine) twonor
//nor_256_23 (out_256 vdd norout256_23 vdd vss PBulkLine NBulkLine) twonor
//nor_256_24 (out_256 vdd norout256_24 vdd vss PBulkLine NBulkLine) twonor
//nor_256_25 (out_256 vdd norout256_25 vdd vss PBulkLine NBulkLine) twonor
//nor_256_26 (out_256 vdd norout256_26 vdd vss PBulkLine NBulkLine) twonor
//nor_256_27 (out_256 vdd norout256_27 vdd vss PBulkLine NBulkLine) twonor
//nor_256_28 (out_256 vdd norout256_28 vdd vss PBulkLine NBulkLine) twonor
//nor_256_29 (out_256 vdd norout256_29 vdd vss PBulkLine NBulkLine) twonor
//nor_256_30 (out_256 vdd norout256_30 vdd vss PBulkLine NBulkLine) twonor
//nor_256_31 (out_256 vdd norout256_31 vdd vss PBulkLine NBulkLine) twonor
//nor_256_32 (out_256 vdd norout256_32 vdd vss PBulkLine NBulkLine) twonor
//nor_256_33 (out_256 vdd norout256_33 vdd vss PBulkLine NBulkLine) twonor
//nor_256_34 (out_256 vdd norout256_34 vdd vss PBulkLine NBulkLine) twonor
//nor_256_35 (out_256 vdd norout256_35 vdd vss PBulkLine NBulkLine) twonor
//nor_256_36 (out_256 vdd norout256_36 vdd vss PBulkLine NBulkLine) twonor
//nor_256_37 (out_256 vdd norout256_37 vdd vss PBulkLine NBulkLine) twonor
//nor_256_38 (out_256 vdd norout256_38 vdd vss PBulkLine NBulkLine) twonor
//nor_256_39 (out_256 vdd norout256_39 vdd vss PBulkLine NBulkLine) twonor
//nor_256_40 (out_256 vdd norout256_40 vdd vss PBulkLine NBulkLine) twonor
//nor_256_41 (out_256 vdd norout256_41 vdd vss PBulkLine NBulkLine) twonor
//nor_256_42 (out_256 vdd norout256_42 vdd vss PBulkLine NBulkLine) twonor
//nor_256_43 (out_256 vdd norout256_43 vdd vss PBulkLine NBulkLine) twonor
//nor_256_44 (out_256 vdd norout256_44 vdd vss PBulkLine NBulkLine) twonor
//nor_256_45 (out_256 vdd norout256_45 vdd vss PBulkLine NBulkLine) twonor
//nor_256_46 (out_256 vdd norout256_46 vdd vss PBulkLine NBulkLine) twonor
//nor_256_47 (out_256 vdd norout256_47 vdd vss PBulkLine NBulkLine) twonor
//nor_256_48 (out_256 vdd norout256_48 vdd vss PBulkLine NBulkLine) twonor
//nor_256_49 (out_256 vdd norout256_49 vdd vss PBulkLine NBulkLine) twonor
//nor_256_50 (out_256 vdd norout256_50 vdd vss PBulkLine NBulkLine) twonor
//nor_256_51 (out_256 vdd norout256_51 vdd vss PBulkLine NBulkLine) twonor
//nor_256_52 (out_256 vdd norout256_52 vdd vss PBulkLine NBulkLine) twonor
//nor_256_53 (out_256 vdd norout256_53 vdd vss PBulkLine NBulkLine) twonor
//nor_256_54 (out_256 vdd norout256_54 vdd vss PBulkLine NBulkLine) twonor
//nor_256_55 (out_256 vdd norout256_55 vdd vss PBulkLine NBulkLine) twonor
//nor_256_56 (out_256 vdd norout256_56 vdd vss PBulkLine NBulkLine) twonor
//nor_256_57 (out_256 vdd norout256_57 vdd vss PBulkLine NBulkLine) twonor
//nor_256_58 (out_256 vdd norout256_58 vdd vss PBulkLine NBulkLine) twonor
//nor_256_59 (out_256 vdd norout256_59 vdd vss PBulkLine NBulkLine) twonor
//nor_256_60 (out_256 vdd norout256_60 vdd vss PBulkLine NBulkLine) twonor
//nor_256_61 (out_256 vdd norout256_61 vdd vss PBulkLine NBulkLine) twonor
//nor_256_62 (out_256 vdd norout256_62 vdd vss PBulkLine NBulkLine) twonor
//nor_256_63 (out_256 vdd norout256_63 vdd vss PBulkLine NBulkLine) twonor
//nor_256_64 (out_256 vdd norout256_64 vdd vss PBulkLine NBulkLine) twonor
//nor_256_65 (out_256 vdd norout256_65 vdd vss PBulkLine NBulkLine) twonor
//nor_256_66 (out_256 vdd norout256_66 vdd vss PBulkLine NBulkLine) twonor
//nor_256_67 (out_256 vdd norout256_67 vdd vss PBulkLine NBulkLine) twonor
//nor_256_68 (out_256 vdd norout256_68 vdd vss PBulkLine NBulkLine) twonor
//nor_256_69 (out_256 vdd norout256_69 vdd vss PBulkLine NBulkLine) twonor
//nor_256_70 (out_256 vdd norout256_70 vdd vss PBulkLine NBulkLine) twonor
//nor_256_71 (out_256 vdd norout256_71 vdd vss PBulkLine NBulkLine) twonor
//nor_256_72 (out_256 vdd norout256_72 vdd vss PBulkLine NBulkLine) twonor
//nor_256_73 (out_256 vdd norout256_73 vdd vss PBulkLine NBulkLine) twonor
//nor_256_74 (out_256 vdd norout256_74 vdd vss PBulkLine NBulkLine) twonor
//nor_256_75 (out_256 vdd norout256_75 vdd vss PBulkLine NBulkLine) twonor
//nor_256_76 (out_256 vdd norout256_76 vdd vss PBulkLine NBulkLine) twonor
//nor_256_77 (out_256 vdd norout256_77 vdd vss PBulkLine NBulkLine) twonor
//nor_256_78 (out_256 vdd norout256_78 vdd vss PBulkLine NBulkLine) twonor
//nor_256_79 (out_256 vdd norout256_79 vdd vss PBulkLine NBulkLine) twonor
//nor_256_80 (out_256 vdd norout256_80 vdd vss PBulkLine NBulkLine) twonor
//nor_256_81 (out_256 vdd norout256_81 vdd vss PBulkLine NBulkLine) twonor
//nor_256_82 (out_256 vdd norout256_82 vdd vss PBulkLine NBulkLine) twonor
//nor_256_83 (out_256 vdd norout256_83 vdd vss PBulkLine NBulkLine) twonor
//nor_256_84 (out_256 vdd norout256_84 vdd vss PBulkLine NBulkLine) twonor
//nor_256_85 (out_256 vdd norout256_85 vdd vss PBulkLine NBulkLine) twonor
//nor_256_86 (out_256 vdd norout256_86 vdd vss PBulkLine NBulkLine) twonor
//nor_256_87 (out_256 vdd norout256_87 vdd vss PBulkLine NBulkLine) twonor
//nor_256_88 (out_256 vdd norout256_88 vdd vss PBulkLine NBulkLine) twonor
//nor_256_89 (out_256 vdd norout256_89 vdd vss PBulkLine NBulkLine) twonor
//nor_256_90 (out_256 vdd norout256_90 vdd vss PBulkLine NBulkLine) twonor
//nor_256_91 (out_256 vdd norout256_91 vdd vss PBulkLine NBulkLine) twonor
//nor_256_92 (out_256 vdd norout256_92 vdd vss PBulkLine NBulkLine) twonor
//nor_256_93 (out_256 vdd norout256_93 vdd vss PBulkLine NBulkLine) twonor
//nor_256_94 (out_256 vdd norout256_94 vdd vss PBulkLine NBulkLine) twonor
//nor_256_95 (out_256 vdd norout256_95 vdd vss PBulkLine NBulkLine) twonor
//nor_256_96 (out_256 vdd norout256_96 vdd vss PBulkLine NBulkLine) twonor
//nor_256_97 (out_256 vdd norout256_97 vdd vss PBulkLine NBulkLine) twonor
//nor_256_98 (out_256 vdd norout256_98 vdd vss PBulkLine NBulkLine) twonor
//nor_256_99 (out_256 vdd norout256_99 vdd vss PBulkLine NBulkLine) twonor
//nor_256_100 (out_256 vdd norout256_100 vdd vss PBulkLine NBulkLine) twonor
//nor_256_101 (out_256 vdd norout256_101 vdd vss PBulkLine NBulkLine) twonor
//nor_256_102 (out_256 vdd norout256_102 vdd vss PBulkLine NBulkLine) twonor
//nor_256_103 (out_256 vdd norout256_103 vdd vss PBulkLine NBulkLine) twonor
//nor_256_104 (out_256 vdd norout256_104 vdd vss PBulkLine NBulkLine) twonor
//nor_256_105 (out_256 vdd norout256_105 vdd vss PBulkLine NBulkLine) twonor
//nor_256_106 (out_256 vdd norout256_106 vdd vss PBulkLine NBulkLine) twonor
//nor_256_107 (out_256 vdd norout256_107 vdd vss PBulkLine NBulkLine) twonor
//nor_256_108 (out_256 vdd norout256_108 vdd vss PBulkLine NBulkLine) twonor
//nor_256_109 (out_256 vdd norout256_109 vdd vss PBulkLine NBulkLine) twonor
//nor_256_110 (out_256 vdd norout256_110 vdd vss PBulkLine NBulkLine) twonor
//nor_256_111 (out_256 vdd norout256_111 vdd vss PBulkLine NBulkLine) twonor
//nor_256_112 (out_256 vdd norout256_112 vdd vss PBulkLine NBulkLine) twonor
//nor_256_113 (out_256 vdd norout256_113 vdd vss PBulkLine NBulkLine) twonor
//nor_256_114 (out_256 vdd norout256_114 vdd vss PBulkLine NBulkLine) twonor
//nor_256_115 (out_256 vdd norout256_115 vdd vss PBulkLine NBulkLine) twonor
//nor_256_116 (out_256 vdd norout256_116 vdd vss PBulkLine NBulkLine) twonor
//nor_256_117 (out_256 vdd norout256_117 vdd vss PBulkLine NBulkLine) twonor
//nor_256_118 (out_256 vdd norout256_118 vdd vss PBulkLine NBulkLine) twonor
//nor_256_119 (out_256 vdd norout256_119 vdd vss PBulkLine NBulkLine) twonor
//nor_256_120 (out_256 vdd norout256_120 vdd vss PBulkLine NBulkLine) twonor
//nor_256_121 (out_256 vdd norout256_121 vdd vss PBulkLine NBulkLine) twonor
//nor_256_122 (out_256 vdd norout256_122 vdd vss PBulkLine NBulkLine) twonor
//nor_256_123 (out_256 vdd norout256_123 vdd vss PBulkLine NBulkLine) twonor
//nor_256_124 (out_256 vdd norout256_124 vdd vss PBulkLine NBulkLine) twonor
//nor_256_125 (out_256 vdd norout256_125 vdd vss PBulkLine NBulkLine) twonor
//nor_256_126 (out_256 vdd norout256_126 vdd vss PBulkLine NBulkLine) twonor
//nor_256_127 (out_256 vdd norout256_127 vdd vss PBulkLine NBulkLine) twonor
//nor_256_128 (out_256 vdd norout256_128 vdd vss PBulkLine NBulkLine) twonor
//nor_256_129 (out_256 vdd norout256_129 vdd vss PBulkLine NBulkLine) twonor
//nor_256_130 (out_256 vdd norout256_130 vdd vss PBulkLine NBulkLine) twonor
//nor_256_131 (out_256 vdd norout256_131 vdd vss PBulkLine NBulkLine) twonor
//nor_256_132 (out_256 vdd norout256_132 vdd vss PBulkLine NBulkLine) twonor
//nor_256_133 (out_256 vdd norout256_133 vdd vss PBulkLine NBulkLine) twonor
//nor_256_134 (out_256 vdd norout256_134 vdd vss PBulkLine NBulkLine) twonor
//nor_256_135 (out_256 vdd norout256_135 vdd vss PBulkLine NBulkLine) twonor
//nor_256_136 (out_256 vdd norout256_136 vdd vss PBulkLine NBulkLine) twonor
//nor_256_137 (out_256 vdd norout256_137 vdd vss PBulkLine NBulkLine) twonor
//nor_256_138 (out_256 vdd norout256_138 vdd vss PBulkLine NBulkLine) twonor
//nor_256_139 (out_256 vdd norout256_139 vdd vss PBulkLine NBulkLine) twonor
//nor_256_140 (out_256 vdd norout256_140 vdd vss PBulkLine NBulkLine) twonor
//nor_256_141 (out_256 vdd norout256_141 vdd vss PBulkLine NBulkLine) twonor
//nor_256_142 (out_256 vdd norout256_142 vdd vss PBulkLine NBulkLine) twonor
//nor_256_143 (out_256 vdd norout256_143 vdd vss PBulkLine NBulkLine) twonor
//nor_256_144 (out_256 vdd norout256_144 vdd vss PBulkLine NBulkLine) twonor
//nor_256_145 (out_256 vdd norout256_145 vdd vss PBulkLine NBulkLine) twonor
//nor_256_146 (out_256 vdd norout256_146 vdd vss PBulkLine NBulkLine) twonor
//nor_256_147 (out_256 vdd norout256_147 vdd vss PBulkLine NBulkLine) twonor
//nor_256_148 (out_256 vdd norout256_148 vdd vss PBulkLine NBulkLine) twonor
//nor_256_149 (out_256 vdd norout256_149 vdd vss PBulkLine NBulkLine) twonor
//nor_256_150 (out_256 vdd norout256_150 vdd vss PBulkLine NBulkLine) twonor
//nor_256_151 (out_256 vdd norout256_151 vdd vss PBulkLine NBulkLine) twonor
//nor_256_152 (out_256 vdd norout256_152 vdd vss PBulkLine NBulkLine) twonor
//nor_256_153 (out_256 vdd norout256_153 vdd vss PBulkLine NBulkLine) twonor
//nor_256_154 (out_256 vdd norout256_154 vdd vss PBulkLine NBulkLine) twonor
//nor_256_155 (out_256 vdd norout256_155 vdd vss PBulkLine NBulkLine) twonor
//nor_256_156 (out_256 vdd norout256_156 vdd vss PBulkLine NBulkLine) twonor
//nor_256_157 (out_256 vdd norout256_157 vdd vss PBulkLine NBulkLine) twonor
//nor_256_158 (out_256 vdd norout256_158 vdd vss PBulkLine NBulkLine) twonor
//nor_256_159 (out_256 vdd norout256_159 vdd vss PBulkLine NBulkLine) twonor
//nor_256_160 (out_256 vdd norout256_160 vdd vss PBulkLine NBulkLine) twonor
//nor_256_161 (out_256 vdd norout256_161 vdd vss PBulkLine NBulkLine) twonor
//nor_256_162 (out_256 vdd norout256_162 vdd vss PBulkLine NBulkLine) twonor
//nor_256_163 (out_256 vdd norout256_163 vdd vss PBulkLine NBulkLine) twonor
//nor_256_164 (out_256 vdd norout256_164 vdd vss PBulkLine NBulkLine) twonor
//nor_256_165 (out_256 vdd norout256_165 vdd vss PBulkLine NBulkLine) twonor
//nor_256_166 (out_256 vdd norout256_166 vdd vss PBulkLine NBulkLine) twonor
//nor_256_167 (out_256 vdd norout256_167 vdd vss PBulkLine NBulkLine) twonor
//nor_256_168 (out_256 vdd norout256_168 vdd vss PBulkLine NBulkLine) twonor
//nor_256_169 (out_256 vdd norout256_169 vdd vss PBulkLine NBulkLine) twonor
//nor_256_170 (out_256 vdd norout256_170 vdd vss PBulkLine NBulkLine) twonor
//nor_256_171 (out_256 vdd norout256_171 vdd vss PBulkLine NBulkLine) twonor
//nor_256_172 (out_256 vdd norout256_172 vdd vss PBulkLine NBulkLine) twonor
//nor_256_173 (out_256 vdd norout256_173 vdd vss PBulkLine NBulkLine) twonor
//nor_256_174 (out_256 vdd norout256_174 vdd vss PBulkLine NBulkLine) twonor
//nor_256_175 (out_256 vdd norout256_175 vdd vss PBulkLine NBulkLine) twonor
//nor_256_176 (out_256 vdd norout256_176 vdd vss PBulkLine NBulkLine) twonor
//nor_256_177 (out_256 vdd norout256_177 vdd vss PBulkLine NBulkLine) twonor
//nor_256_178 (out_256 vdd norout256_178 vdd vss PBulkLine NBulkLine) twonor
//nor_256_179 (out_256 vdd norout256_179 vdd vss PBulkLine NBulkLine) twonor
//nor_256_180 (out_256 vdd norout256_180 vdd vss PBulkLine NBulkLine) twonor
//nor_256_181 (out_256 vdd norout256_181 vdd vss PBulkLine NBulkLine) twonor
//nor_256_182 (out_256 vdd norout256_182 vdd vss PBulkLine NBulkLine) twonor
//nor_256_183 (out_256 vdd norout256_183 vdd vss PBulkLine NBulkLine) twonor
//nor_256_184 (out_256 vdd norout256_184 vdd vss PBulkLine NBulkLine) twonor
//nor_256_185 (out_256 vdd norout256_185 vdd vss PBulkLine NBulkLine) twonor
//nor_256_186 (out_256 vdd norout256_186 vdd vss PBulkLine NBulkLine) twonor
//nor_256_187 (out_256 vdd norout256_187 vdd vss PBulkLine NBulkLine) twonor
//nor_256_188 (out_256 vdd norout256_188 vdd vss PBulkLine NBulkLine) twonor
//nor_256_189 (out_256 vdd norout256_189 vdd vss PBulkLine NBulkLine) twonor
//nor_256_190 (out_256 vdd norout256_190 vdd vss PBulkLine NBulkLine) twonor
//nor_256_191 (out_256 vdd norout256_191 vdd vss PBulkLine NBulkLine) twonor
//nor_256_192 (out_256 vdd norout256_192 vdd vss PBulkLine NBulkLine) twonor
//nor_256_193 (out_256 vdd norout256_193 vdd vss PBulkLine NBulkLine) twonor
//nor_256_194 (out_256 vdd norout256_194 vdd vss PBulkLine NBulkLine) twonor
//nor_256_195 (out_256 vdd norout256_195 vdd vss PBulkLine NBulkLine) twonor
//nor_256_196 (out_256 vdd norout256_196 vdd vss PBulkLine NBulkLine) twonor
//nor_256_197 (out_256 vdd norout256_197 vdd vss PBulkLine NBulkLine) twonor
//nor_256_198 (out_256 vdd norout256_198 vdd vss PBulkLine NBulkLine) twonor
//nor_256_199 (out_256 vdd norout256_199 vdd vss PBulkLine NBulkLine) twonor
//nor_256_200 (out_256 vdd norout256_200 vdd vss PBulkLine NBulkLine) twonor
//nor_256_201 (out_256 vdd norout256_201 vdd vss PBulkLine NBulkLine) twonor
//nor_256_202 (out_256 vdd norout256_202 vdd vss PBulkLine NBulkLine) twonor
//nor_256_203 (out_256 vdd norout256_203 vdd vss PBulkLine NBulkLine) twonor
//nor_256_204 (out_256 vdd norout256_204 vdd vss PBulkLine NBulkLine) twonor
//nor_256_205 (out_256 vdd norout256_205 vdd vss PBulkLine NBulkLine) twonor
//nor_256_206 (out_256 vdd norout256_206 vdd vss PBulkLine NBulkLine) twonor
//nor_256_207 (out_256 vdd norout256_207 vdd vss PBulkLine NBulkLine) twonor
//nor_256_208 (out_256 vdd norout256_208 vdd vss PBulkLine NBulkLine) twonor
//nor_256_209 (out_256 vdd norout256_209 vdd vss PBulkLine NBulkLine) twonor
//nor_256_210 (out_256 vdd norout256_210 vdd vss PBulkLine NBulkLine) twonor
//nor_256_211 (out_256 vdd norout256_211 vdd vss PBulkLine NBulkLine) twonor
//nor_256_212 (out_256 vdd norout256_212 vdd vss PBulkLine NBulkLine) twonor
//nor_256_213 (out_256 vdd norout256_213 vdd vss PBulkLine NBulkLine) twonor
//nor_256_214 (out_256 vdd norout256_214 vdd vss PBulkLine NBulkLine) twonor
//nor_256_215 (out_256 vdd norout256_215 vdd vss PBulkLine NBulkLine) twonor
//nor_256_216 (out_256 vdd norout256_216 vdd vss PBulkLine NBulkLine) twonor
//nor_256_217 (out_256 vdd norout256_217 vdd vss PBulkLine NBulkLine) twonor
//nor_256_218 (out_256 vdd norout256_218 vdd vss PBulkLine NBulkLine) twonor
//nor_256_219 (out_256 vdd norout256_219 vdd vss PBulkLine NBulkLine) twonor
//nor_256_220 (out_256 vdd norout256_220 vdd vss PBulkLine NBulkLine) twonor
//nor_256_221 (out_256 vdd norout256_221 vdd vss PBulkLine NBulkLine) twonor
//nor_256_222 (out_256 vdd norout256_222 vdd vss PBulkLine NBulkLine) twonor
//nor_256_223 (out_256 vdd norout256_223 vdd vss PBulkLine NBulkLine) twonor
//nor_256_224 (out_256 vdd norout256_224 vdd vss PBulkLine NBulkLine) twonor
//nor_256_225 (out_256 vdd norout256_225 vdd vss PBulkLine NBulkLine) twonor
//nor_256_226 (out_256 vdd norout256_226 vdd vss PBulkLine NBulkLine) twonor
//nor_256_227 (out_256 vdd norout256_227 vdd vss PBulkLine NBulkLine) twonor
//nor_256_228 (out_256 vdd norout256_228 vdd vss PBulkLine NBulkLine) twonor
//nor_256_229 (out_256 vdd norout256_229 vdd vss PBulkLine NBulkLine) twonor
//nor_256_230 (out_256 vdd norout256_230 vdd vss PBulkLine NBulkLine) twonor
//nor_256_231 (out_256 vdd norout256_231 vdd vss PBulkLine NBulkLine) twonor
//nor_256_232 (out_256 vdd norout256_232 vdd vss PBulkLine NBulkLine) twonor
//nor_256_233 (out_256 vdd norout256_233 vdd vss PBulkLine NBulkLine) twonor
//nor_256_234 (out_256 vdd norout256_234 vdd vss PBulkLine NBulkLine) twonor
//nor_256_235 (out_256 vdd norout256_235 vdd vss PBulkLine NBulkLine) twonor
//nor_256_236 (out_256 vdd norout256_236 vdd vss PBulkLine NBulkLine) twonor
//nor_256_237 (out_256 vdd norout256_237 vdd vss PBulkLine NBulkLine) twonor
//nor_256_238 (out_256 vdd norout256_238 vdd vss PBulkLine NBulkLine) twonor
//nor_256_239 (out_256 vdd norout256_239 vdd vss PBulkLine NBulkLine) twonor
//nor_256_240 (out_256 vdd norout256_240 vdd vss PBulkLine NBulkLine) twonor
//nor_256_241 (out_256 vdd norout256_241 vdd vss PBulkLine NBulkLine) twonor
//nor_256_242 (out_256 vdd norout256_242 vdd vss PBulkLine NBulkLine) twonor
//nor_256_243 (out_256 vdd norout256_243 vdd vss PBulkLine NBulkLine) twonor
//nor_256_244 (out_256 vdd norout256_244 vdd vss PBulkLine NBulkLine) twonor
//nor_256_245 (out_256 vdd norout256_245 vdd vss PBulkLine NBulkLine) twonor
//nor_256_246 (out_256 vdd norout256_246 vdd vss PBulkLine NBulkLine) twonor
//nor_256_247 (out_256 vdd norout256_247 vdd vss PBulkLine NBulkLine) twonor
//nor_256_248 (out_256 vdd norout256_248 vdd vss PBulkLine NBulkLine) twonor
//nor_256_249 (out_256 vdd norout256_249 vdd vss PBulkLine NBulkLine) twonor
//nor_256_250 (out_256 vdd norout256_250 vdd vss PBulkLine NBulkLine) twonor
//nor_256_251 (out_256 vdd norout256_251 vdd vss PBulkLine NBulkLine) twonor
//nor_256_252 (out_256 vdd norout256_252 vdd vss PBulkLine NBulkLine) twonor
//nor_256_253 (out_256 vdd norout256_253 vdd vss PBulkLine NBulkLine) twonor
//nor_256_254 (out_256 vdd norout256_254 vdd vss PBulkLine NBulkLine) twonor
//nor_256_255 (out_256 vdd norout256_255 vdd vss PBulkLine NBulkLine) twonor
//nor_256_256 (out_256 vdd norout256_256 vdd vss PBulkLine NBulkLine) twonor
cPar_256 out_256 vss capacitor c=4.608e-14
xbuffer_512 (vdd vss vss vdd in out_512) buffer_INVNOR_fivehundredandtwelve
//nor_512_1 (out_512 vdd norout512_1 vdd vss PBulkLine NBulkLine) twonor
//nor_512_2 (out_512 vdd norout512_2 vdd vss PBulkLine NBulkLine) twonor
//nor_512_3 (out_512 vdd norout512_3 vdd vss PBulkLine NBulkLine) twonor
//nor_512_4 (out_512 vdd norout512_4 vdd vss PBulkLine NBulkLine) twonor
//nor_512_5 (out_512 vdd norout512_5 vdd vss PBulkLine NBulkLine) twonor
//nor_512_6 (out_512 vdd norout512_6 vdd vss PBulkLine NBulkLine) twonor
//nor_512_7 (out_512 vdd norout512_7 vdd vss PBulkLine NBulkLine) twonor
//nor_512_8 (out_512 vdd norout512_8 vdd vss PBulkLine NBulkLine) twonor
//nor_512_9 (out_512 vdd norout512_9 vdd vss PBulkLine NBulkLine) twonor
//nor_512_10 (out_512 vdd norout512_10 vdd vss PBulkLine NBulkLine) twonor
//nor_512_11 (out_512 vdd norout512_11 vdd vss PBulkLine NBulkLine) twonor
//nor_512_12 (out_512 vdd norout512_12 vdd vss PBulkLine NBulkLine) twonor
//nor_512_13 (out_512 vdd norout512_13 vdd vss PBulkLine NBulkLine) twonor
//nor_512_14 (out_512 vdd norout512_14 vdd vss PBulkLine NBulkLine) twonor
//nor_512_15 (out_512 vdd norout512_15 vdd vss PBulkLine NBulkLine) twonor
//nor_512_16 (out_512 vdd norout512_16 vdd vss PBulkLine NBulkLine) twonor
//nor_512_17 (out_512 vdd norout512_17 vdd vss PBulkLine NBulkLine) twonor
//nor_512_18 (out_512 vdd norout512_18 vdd vss PBulkLine NBulkLine) twonor
//nor_512_19 (out_512 vdd norout512_19 vdd vss PBulkLine NBulkLine) twonor
//nor_512_20 (out_512 vdd norout512_20 vdd vss PBulkLine NBulkLine) twonor
//nor_512_21 (out_512 vdd norout512_21 vdd vss PBulkLine NBulkLine) twonor
//nor_512_22 (out_512 vdd norout512_22 vdd vss PBulkLine NBulkLine) twonor
//nor_512_23 (out_512 vdd norout512_23 vdd vss PBulkLine NBulkLine) twonor
//nor_512_24 (out_512 vdd norout512_24 vdd vss PBulkLine NBulkLine) twonor
//nor_512_25 (out_512 vdd norout512_25 vdd vss PBulkLine NBulkLine) twonor
//nor_512_26 (out_512 vdd norout512_26 vdd vss PBulkLine NBulkLine) twonor
//nor_512_27 (out_512 vdd norout512_27 vdd vss PBulkLine NBulkLine) twonor
//nor_512_28 (out_512 vdd norout512_28 vdd vss PBulkLine NBulkLine) twonor
//nor_512_29 (out_512 vdd norout512_29 vdd vss PBulkLine NBulkLine) twonor
//nor_512_30 (out_512 vdd norout512_30 vdd vss PBulkLine NBulkLine) twonor
//nor_512_31 (out_512 vdd norout512_31 vdd vss PBulkLine NBulkLine) twonor
//nor_512_32 (out_512 vdd norout512_32 vdd vss PBulkLine NBulkLine) twonor
//nor_512_33 (out_512 vdd norout512_33 vdd vss PBulkLine NBulkLine) twonor
//nor_512_34 (out_512 vdd norout512_34 vdd vss PBulkLine NBulkLine) twonor
//nor_512_35 (out_512 vdd norout512_35 vdd vss PBulkLine NBulkLine) twonor
//nor_512_36 (out_512 vdd norout512_36 vdd vss PBulkLine NBulkLine) twonor
//nor_512_37 (out_512 vdd norout512_37 vdd vss PBulkLine NBulkLine) twonor
//nor_512_38 (out_512 vdd norout512_38 vdd vss PBulkLine NBulkLine) twonor
//nor_512_39 (out_512 vdd norout512_39 vdd vss PBulkLine NBulkLine) twonor
//nor_512_40 (out_512 vdd norout512_40 vdd vss PBulkLine NBulkLine) twonor
//nor_512_41 (out_512 vdd norout512_41 vdd vss PBulkLine NBulkLine) twonor
//nor_512_42 (out_512 vdd norout512_42 vdd vss PBulkLine NBulkLine) twonor
//nor_512_43 (out_512 vdd norout512_43 vdd vss PBulkLine NBulkLine) twonor
//nor_512_44 (out_512 vdd norout512_44 vdd vss PBulkLine NBulkLine) twonor
//nor_512_45 (out_512 vdd norout512_45 vdd vss PBulkLine NBulkLine) twonor
//nor_512_46 (out_512 vdd norout512_46 vdd vss PBulkLine NBulkLine) twonor
//nor_512_47 (out_512 vdd norout512_47 vdd vss PBulkLine NBulkLine) twonor
//nor_512_48 (out_512 vdd norout512_48 vdd vss PBulkLine NBulkLine) twonor
//nor_512_49 (out_512 vdd norout512_49 vdd vss PBulkLine NBulkLine) twonor
//nor_512_50 (out_512 vdd norout512_50 vdd vss PBulkLine NBulkLine) twonor
//nor_512_51 (out_512 vdd norout512_51 vdd vss PBulkLine NBulkLine) twonor
//nor_512_52 (out_512 vdd norout512_52 vdd vss PBulkLine NBulkLine) twonor
//nor_512_53 (out_512 vdd norout512_53 vdd vss PBulkLine NBulkLine) twonor
//nor_512_54 (out_512 vdd norout512_54 vdd vss PBulkLine NBulkLine) twonor
//nor_512_55 (out_512 vdd norout512_55 vdd vss PBulkLine NBulkLine) twonor
//nor_512_56 (out_512 vdd norout512_56 vdd vss PBulkLine NBulkLine) twonor
//nor_512_57 (out_512 vdd norout512_57 vdd vss PBulkLine NBulkLine) twonor
//nor_512_58 (out_512 vdd norout512_58 vdd vss PBulkLine NBulkLine) twonor
//nor_512_59 (out_512 vdd norout512_59 vdd vss PBulkLine NBulkLine) twonor
//nor_512_60 (out_512 vdd norout512_60 vdd vss PBulkLine NBulkLine) twonor
//nor_512_61 (out_512 vdd norout512_61 vdd vss PBulkLine NBulkLine) twonor
//nor_512_62 (out_512 vdd norout512_62 vdd vss PBulkLine NBulkLine) twonor
//nor_512_63 (out_512 vdd norout512_63 vdd vss PBulkLine NBulkLine) twonor
//nor_512_64 (out_512 vdd norout512_64 vdd vss PBulkLine NBulkLine) twonor
//nor_512_65 (out_512 vdd norout512_65 vdd vss PBulkLine NBulkLine) twonor
//nor_512_66 (out_512 vdd norout512_66 vdd vss PBulkLine NBulkLine) twonor
//nor_512_67 (out_512 vdd norout512_67 vdd vss PBulkLine NBulkLine) twonor
//nor_512_68 (out_512 vdd norout512_68 vdd vss PBulkLine NBulkLine) twonor
//nor_512_69 (out_512 vdd norout512_69 vdd vss PBulkLine NBulkLine) twonor
//nor_512_70 (out_512 vdd norout512_70 vdd vss PBulkLine NBulkLine) twonor
//nor_512_71 (out_512 vdd norout512_71 vdd vss PBulkLine NBulkLine) twonor
//nor_512_72 (out_512 vdd norout512_72 vdd vss PBulkLine NBulkLine) twonor
//nor_512_73 (out_512 vdd norout512_73 vdd vss PBulkLine NBulkLine) twonor
//nor_512_74 (out_512 vdd norout512_74 vdd vss PBulkLine NBulkLine) twonor
//nor_512_75 (out_512 vdd norout512_75 vdd vss PBulkLine NBulkLine) twonor
//nor_512_76 (out_512 vdd norout512_76 vdd vss PBulkLine NBulkLine) twonor
//nor_512_77 (out_512 vdd norout512_77 vdd vss PBulkLine NBulkLine) twonor
//nor_512_78 (out_512 vdd norout512_78 vdd vss PBulkLine NBulkLine) twonor
//nor_512_79 (out_512 vdd norout512_79 vdd vss PBulkLine NBulkLine) twonor
//nor_512_80 (out_512 vdd norout512_80 vdd vss PBulkLine NBulkLine) twonor
//nor_512_81 (out_512 vdd norout512_81 vdd vss PBulkLine NBulkLine) twonor
//nor_512_82 (out_512 vdd norout512_82 vdd vss PBulkLine NBulkLine) twonor
//nor_512_83 (out_512 vdd norout512_83 vdd vss PBulkLine NBulkLine) twonor
//nor_512_84 (out_512 vdd norout512_84 vdd vss PBulkLine NBulkLine) twonor
//nor_512_85 (out_512 vdd norout512_85 vdd vss PBulkLine NBulkLine) twonor
//nor_512_86 (out_512 vdd norout512_86 vdd vss PBulkLine NBulkLine) twonor
//nor_512_87 (out_512 vdd norout512_87 vdd vss PBulkLine NBulkLine) twonor
//nor_512_88 (out_512 vdd norout512_88 vdd vss PBulkLine NBulkLine) twonor
//nor_512_89 (out_512 vdd norout512_89 vdd vss PBulkLine NBulkLine) twonor
//nor_512_90 (out_512 vdd norout512_90 vdd vss PBulkLine NBulkLine) twonor
//nor_512_91 (out_512 vdd norout512_91 vdd vss PBulkLine NBulkLine) twonor
//nor_512_92 (out_512 vdd norout512_92 vdd vss PBulkLine NBulkLine) twonor
//nor_512_93 (out_512 vdd norout512_93 vdd vss PBulkLine NBulkLine) twonor
//nor_512_94 (out_512 vdd norout512_94 vdd vss PBulkLine NBulkLine) twonor
//nor_512_95 (out_512 vdd norout512_95 vdd vss PBulkLine NBulkLine) twonor
//nor_512_96 (out_512 vdd norout512_96 vdd vss PBulkLine NBulkLine) twonor
//nor_512_97 (out_512 vdd norout512_97 vdd vss PBulkLine NBulkLine) twonor
//nor_512_98 (out_512 vdd norout512_98 vdd vss PBulkLine NBulkLine) twonor
//nor_512_99 (out_512 vdd norout512_99 vdd vss PBulkLine NBulkLine) twonor
//nor_512_100 (out_512 vdd norout512_100 vdd vss PBulkLine NBulkLine) twonor
//nor_512_101 (out_512 vdd norout512_101 vdd vss PBulkLine NBulkLine) twonor
//nor_512_102 (out_512 vdd norout512_102 vdd vss PBulkLine NBulkLine) twonor
//nor_512_103 (out_512 vdd norout512_103 vdd vss PBulkLine NBulkLine) twonor
//nor_512_104 (out_512 vdd norout512_104 vdd vss PBulkLine NBulkLine) twonor
//nor_512_105 (out_512 vdd norout512_105 vdd vss PBulkLine NBulkLine) twonor
//nor_512_106 (out_512 vdd norout512_106 vdd vss PBulkLine NBulkLine) twonor
//nor_512_107 (out_512 vdd norout512_107 vdd vss PBulkLine NBulkLine) twonor
//nor_512_108 (out_512 vdd norout512_108 vdd vss PBulkLine NBulkLine) twonor
//nor_512_109 (out_512 vdd norout512_109 vdd vss PBulkLine NBulkLine) twonor
//nor_512_110 (out_512 vdd norout512_110 vdd vss PBulkLine NBulkLine) twonor
//nor_512_111 (out_512 vdd norout512_111 vdd vss PBulkLine NBulkLine) twonor
//nor_512_112 (out_512 vdd norout512_112 vdd vss PBulkLine NBulkLine) twonor
//nor_512_113 (out_512 vdd norout512_113 vdd vss PBulkLine NBulkLine) twonor
//nor_512_114 (out_512 vdd norout512_114 vdd vss PBulkLine NBulkLine) twonor
//nor_512_115 (out_512 vdd norout512_115 vdd vss PBulkLine NBulkLine) twonor
//nor_512_116 (out_512 vdd norout512_116 vdd vss PBulkLine NBulkLine) twonor
//nor_512_117 (out_512 vdd norout512_117 vdd vss PBulkLine NBulkLine) twonor
//nor_512_118 (out_512 vdd norout512_118 vdd vss PBulkLine NBulkLine) twonor
//nor_512_119 (out_512 vdd norout512_119 vdd vss PBulkLine NBulkLine) twonor
//nor_512_120 (out_512 vdd norout512_120 vdd vss PBulkLine NBulkLine) twonor
//nor_512_121 (out_512 vdd norout512_121 vdd vss PBulkLine NBulkLine) twonor
//nor_512_122 (out_512 vdd norout512_122 vdd vss PBulkLine NBulkLine) twonor
//nor_512_123 (out_512 vdd norout512_123 vdd vss PBulkLine NBulkLine) twonor
//nor_512_124 (out_512 vdd norout512_124 vdd vss PBulkLine NBulkLine) twonor
//nor_512_125 (out_512 vdd norout512_125 vdd vss PBulkLine NBulkLine) twonor
//nor_512_126 (out_512 vdd norout512_126 vdd vss PBulkLine NBulkLine) twonor
//nor_512_127 (out_512 vdd norout512_127 vdd vss PBulkLine NBulkLine) twonor
//nor_512_128 (out_512 vdd norout512_128 vdd vss PBulkLine NBulkLine) twonor
//nor_512_129 (out_512 vdd norout512_129 vdd vss PBulkLine NBulkLine) twonor
//nor_512_130 (out_512 vdd norout512_130 vdd vss PBulkLine NBulkLine) twonor
//nor_512_131 (out_512 vdd norout512_131 vdd vss PBulkLine NBulkLine) twonor
//nor_512_132 (out_512 vdd norout512_132 vdd vss PBulkLine NBulkLine) twonor
//nor_512_133 (out_512 vdd norout512_133 vdd vss PBulkLine NBulkLine) twonor
//nor_512_134 (out_512 vdd norout512_134 vdd vss PBulkLine NBulkLine) twonor
//nor_512_135 (out_512 vdd norout512_135 vdd vss PBulkLine NBulkLine) twonor
//nor_512_136 (out_512 vdd norout512_136 vdd vss PBulkLine NBulkLine) twonor
//nor_512_137 (out_512 vdd norout512_137 vdd vss PBulkLine NBulkLine) twonor
//nor_512_138 (out_512 vdd norout512_138 vdd vss PBulkLine NBulkLine) twonor
//nor_512_139 (out_512 vdd norout512_139 vdd vss PBulkLine NBulkLine) twonor
//nor_512_140 (out_512 vdd norout512_140 vdd vss PBulkLine NBulkLine) twonor
//nor_512_141 (out_512 vdd norout512_141 vdd vss PBulkLine NBulkLine) twonor
//nor_512_142 (out_512 vdd norout512_142 vdd vss PBulkLine NBulkLine) twonor
//nor_512_143 (out_512 vdd norout512_143 vdd vss PBulkLine NBulkLine) twonor
//nor_512_144 (out_512 vdd norout512_144 vdd vss PBulkLine NBulkLine) twonor
//nor_512_145 (out_512 vdd norout512_145 vdd vss PBulkLine NBulkLine) twonor
//nor_512_146 (out_512 vdd norout512_146 vdd vss PBulkLine NBulkLine) twonor
//nor_512_147 (out_512 vdd norout512_147 vdd vss PBulkLine NBulkLine) twonor
//nor_512_148 (out_512 vdd norout512_148 vdd vss PBulkLine NBulkLine) twonor
//nor_512_149 (out_512 vdd norout512_149 vdd vss PBulkLine NBulkLine) twonor
//nor_512_150 (out_512 vdd norout512_150 vdd vss PBulkLine NBulkLine) twonor
//nor_512_151 (out_512 vdd norout512_151 vdd vss PBulkLine NBulkLine) twonor
//nor_512_152 (out_512 vdd norout512_152 vdd vss PBulkLine NBulkLine) twonor
//nor_512_153 (out_512 vdd norout512_153 vdd vss PBulkLine NBulkLine) twonor
//nor_512_154 (out_512 vdd norout512_154 vdd vss PBulkLine NBulkLine) twonor
//nor_512_155 (out_512 vdd norout512_155 vdd vss PBulkLine NBulkLine) twonor
//nor_512_156 (out_512 vdd norout512_156 vdd vss PBulkLine NBulkLine) twonor
//nor_512_157 (out_512 vdd norout512_157 vdd vss PBulkLine NBulkLine) twonor
//nor_512_158 (out_512 vdd norout512_158 vdd vss PBulkLine NBulkLine) twonor
//nor_512_159 (out_512 vdd norout512_159 vdd vss PBulkLine NBulkLine) twonor
//nor_512_160 (out_512 vdd norout512_160 vdd vss PBulkLine NBulkLine) twonor
//nor_512_161 (out_512 vdd norout512_161 vdd vss PBulkLine NBulkLine) twonor
//nor_512_162 (out_512 vdd norout512_162 vdd vss PBulkLine NBulkLine) twonor
//nor_512_163 (out_512 vdd norout512_163 vdd vss PBulkLine NBulkLine) twonor
//nor_512_164 (out_512 vdd norout512_164 vdd vss PBulkLine NBulkLine) twonor
//nor_512_165 (out_512 vdd norout512_165 vdd vss PBulkLine NBulkLine) twonor
//nor_512_166 (out_512 vdd norout512_166 vdd vss PBulkLine NBulkLine) twonor
//nor_512_167 (out_512 vdd norout512_167 vdd vss PBulkLine NBulkLine) twonor
//nor_512_168 (out_512 vdd norout512_168 vdd vss PBulkLine NBulkLine) twonor
//nor_512_169 (out_512 vdd norout512_169 vdd vss PBulkLine NBulkLine) twonor
//nor_512_170 (out_512 vdd norout512_170 vdd vss PBulkLine NBulkLine) twonor
//nor_512_171 (out_512 vdd norout512_171 vdd vss PBulkLine NBulkLine) twonor
//nor_512_172 (out_512 vdd norout512_172 vdd vss PBulkLine NBulkLine) twonor
//nor_512_173 (out_512 vdd norout512_173 vdd vss PBulkLine NBulkLine) twonor
//nor_512_174 (out_512 vdd norout512_174 vdd vss PBulkLine NBulkLine) twonor
//nor_512_175 (out_512 vdd norout512_175 vdd vss PBulkLine NBulkLine) twonor
//nor_512_176 (out_512 vdd norout512_176 vdd vss PBulkLine NBulkLine) twonor
//nor_512_177 (out_512 vdd norout512_177 vdd vss PBulkLine NBulkLine) twonor
//nor_512_178 (out_512 vdd norout512_178 vdd vss PBulkLine NBulkLine) twonor
//nor_512_179 (out_512 vdd norout512_179 vdd vss PBulkLine NBulkLine) twonor
//nor_512_180 (out_512 vdd norout512_180 vdd vss PBulkLine NBulkLine) twonor
//nor_512_181 (out_512 vdd norout512_181 vdd vss PBulkLine NBulkLine) twonor
//nor_512_182 (out_512 vdd norout512_182 vdd vss PBulkLine NBulkLine) twonor
//nor_512_183 (out_512 vdd norout512_183 vdd vss PBulkLine NBulkLine) twonor
//nor_512_184 (out_512 vdd norout512_184 vdd vss PBulkLine NBulkLine) twonor
//nor_512_185 (out_512 vdd norout512_185 vdd vss PBulkLine NBulkLine) twonor
//nor_512_186 (out_512 vdd norout512_186 vdd vss PBulkLine NBulkLine) twonor
//nor_512_187 (out_512 vdd norout512_187 vdd vss PBulkLine NBulkLine) twonor
//nor_512_188 (out_512 vdd norout512_188 vdd vss PBulkLine NBulkLine) twonor
//nor_512_189 (out_512 vdd norout512_189 vdd vss PBulkLine NBulkLine) twonor
//nor_512_190 (out_512 vdd norout512_190 vdd vss PBulkLine NBulkLine) twonor
//nor_512_191 (out_512 vdd norout512_191 vdd vss PBulkLine NBulkLine) twonor
//nor_512_192 (out_512 vdd norout512_192 vdd vss PBulkLine NBulkLine) twonor
//nor_512_193 (out_512 vdd norout512_193 vdd vss PBulkLine NBulkLine) twonor
//nor_512_194 (out_512 vdd norout512_194 vdd vss PBulkLine NBulkLine) twonor
//nor_512_195 (out_512 vdd norout512_195 vdd vss PBulkLine NBulkLine) twonor
//nor_512_196 (out_512 vdd norout512_196 vdd vss PBulkLine NBulkLine) twonor
//nor_512_197 (out_512 vdd norout512_197 vdd vss PBulkLine NBulkLine) twonor
//nor_512_198 (out_512 vdd norout512_198 vdd vss PBulkLine NBulkLine) twonor
//nor_512_199 (out_512 vdd norout512_199 vdd vss PBulkLine NBulkLine) twonor
//nor_512_200 (out_512 vdd norout512_200 vdd vss PBulkLine NBulkLine) twonor
//nor_512_201 (out_512 vdd norout512_201 vdd vss PBulkLine NBulkLine) twonor
//nor_512_202 (out_512 vdd norout512_202 vdd vss PBulkLine NBulkLine) twonor
//nor_512_203 (out_512 vdd norout512_203 vdd vss PBulkLine NBulkLine) twonor
//nor_512_204 (out_512 vdd norout512_204 vdd vss PBulkLine NBulkLine) twonor
//nor_512_205 (out_512 vdd norout512_205 vdd vss PBulkLine NBulkLine) twonor
//nor_512_206 (out_512 vdd norout512_206 vdd vss PBulkLine NBulkLine) twonor
//nor_512_207 (out_512 vdd norout512_207 vdd vss PBulkLine NBulkLine) twonor
//nor_512_208 (out_512 vdd norout512_208 vdd vss PBulkLine NBulkLine) twonor
//nor_512_209 (out_512 vdd norout512_209 vdd vss PBulkLine NBulkLine) twonor
//nor_512_210 (out_512 vdd norout512_210 vdd vss PBulkLine NBulkLine) twonor
//nor_512_211 (out_512 vdd norout512_211 vdd vss PBulkLine NBulkLine) twonor
//nor_512_212 (out_512 vdd norout512_212 vdd vss PBulkLine NBulkLine) twonor
//nor_512_213 (out_512 vdd norout512_213 vdd vss PBulkLine NBulkLine) twonor
//nor_512_214 (out_512 vdd norout512_214 vdd vss PBulkLine NBulkLine) twonor
//nor_512_215 (out_512 vdd norout512_215 vdd vss PBulkLine NBulkLine) twonor
//nor_512_216 (out_512 vdd norout512_216 vdd vss PBulkLine NBulkLine) twonor
//nor_512_217 (out_512 vdd norout512_217 vdd vss PBulkLine NBulkLine) twonor
//nor_512_218 (out_512 vdd norout512_218 vdd vss PBulkLine NBulkLine) twonor
//nor_512_219 (out_512 vdd norout512_219 vdd vss PBulkLine NBulkLine) twonor
//nor_512_220 (out_512 vdd norout512_220 vdd vss PBulkLine NBulkLine) twonor
//nor_512_221 (out_512 vdd norout512_221 vdd vss PBulkLine NBulkLine) twonor
//nor_512_222 (out_512 vdd norout512_222 vdd vss PBulkLine NBulkLine) twonor
//nor_512_223 (out_512 vdd norout512_223 vdd vss PBulkLine NBulkLine) twonor
//nor_512_224 (out_512 vdd norout512_224 vdd vss PBulkLine NBulkLine) twonor
//nor_512_225 (out_512 vdd norout512_225 vdd vss PBulkLine NBulkLine) twonor
//nor_512_226 (out_512 vdd norout512_226 vdd vss PBulkLine NBulkLine) twonor
//nor_512_227 (out_512 vdd norout512_227 vdd vss PBulkLine NBulkLine) twonor
//nor_512_228 (out_512 vdd norout512_228 vdd vss PBulkLine NBulkLine) twonor
//nor_512_229 (out_512 vdd norout512_229 vdd vss PBulkLine NBulkLine) twonor
//nor_512_230 (out_512 vdd norout512_230 vdd vss PBulkLine NBulkLine) twonor
//nor_512_231 (out_512 vdd norout512_231 vdd vss PBulkLine NBulkLine) twonor
//nor_512_232 (out_512 vdd norout512_232 vdd vss PBulkLine NBulkLine) twonor
//nor_512_233 (out_512 vdd norout512_233 vdd vss PBulkLine NBulkLine) twonor
//nor_512_234 (out_512 vdd norout512_234 vdd vss PBulkLine NBulkLine) twonor
//nor_512_235 (out_512 vdd norout512_235 vdd vss PBulkLine NBulkLine) twonor
//nor_512_236 (out_512 vdd norout512_236 vdd vss PBulkLine NBulkLine) twonor
//nor_512_237 (out_512 vdd norout512_237 vdd vss PBulkLine NBulkLine) twonor
//nor_512_238 (out_512 vdd norout512_238 vdd vss PBulkLine NBulkLine) twonor
//nor_512_239 (out_512 vdd norout512_239 vdd vss PBulkLine NBulkLine) twonor
//nor_512_240 (out_512 vdd norout512_240 vdd vss PBulkLine NBulkLine) twonor
//nor_512_241 (out_512 vdd norout512_241 vdd vss PBulkLine NBulkLine) twonor
//nor_512_242 (out_512 vdd norout512_242 vdd vss PBulkLine NBulkLine) twonor
//nor_512_243 (out_512 vdd norout512_243 vdd vss PBulkLine NBulkLine) twonor
//nor_512_244 (out_512 vdd norout512_244 vdd vss PBulkLine NBulkLine) twonor
//nor_512_245 (out_512 vdd norout512_245 vdd vss PBulkLine NBulkLine) twonor
//nor_512_246 (out_512 vdd norout512_246 vdd vss PBulkLine NBulkLine) twonor
//nor_512_247 (out_512 vdd norout512_247 vdd vss PBulkLine NBulkLine) twonor
//nor_512_248 (out_512 vdd norout512_248 vdd vss PBulkLine NBulkLine) twonor
//nor_512_249 (out_512 vdd norout512_249 vdd vss PBulkLine NBulkLine) twonor
//nor_512_250 (out_512 vdd norout512_250 vdd vss PBulkLine NBulkLine) twonor
//nor_512_251 (out_512 vdd norout512_251 vdd vss PBulkLine NBulkLine) twonor
//nor_512_252 (out_512 vdd norout512_252 vdd vss PBulkLine NBulkLine) twonor
//nor_512_253 (out_512 vdd norout512_253 vdd vss PBulkLine NBulkLine) twonor
//nor_512_254 (out_512 vdd norout512_254 vdd vss PBulkLine NBulkLine) twonor
//nor_512_255 (out_512 vdd norout512_255 vdd vss PBulkLine NBulkLine) twonor
//nor_512_256 (out_512 vdd norout512_256 vdd vss PBulkLine NBulkLine) twonor
//nor_512_257 (out_512 vdd norout512_257 vdd vss PBulkLine NBulkLine) twonor
//nor_512_258 (out_512 vdd norout512_258 vdd vss PBulkLine NBulkLine) twonor
//nor_512_259 (out_512 vdd norout512_259 vdd vss PBulkLine NBulkLine) twonor
//nor_512_260 (out_512 vdd norout512_260 vdd vss PBulkLine NBulkLine) twonor
//nor_512_261 (out_512 vdd norout512_261 vdd vss PBulkLine NBulkLine) twonor
//nor_512_262 (out_512 vdd norout512_262 vdd vss PBulkLine NBulkLine) twonor
//nor_512_263 (out_512 vdd norout512_263 vdd vss PBulkLine NBulkLine) twonor
//nor_512_264 (out_512 vdd norout512_264 vdd vss PBulkLine NBulkLine) twonor
//nor_512_265 (out_512 vdd norout512_265 vdd vss PBulkLine NBulkLine) twonor
//nor_512_266 (out_512 vdd norout512_266 vdd vss PBulkLine NBulkLine) twonor
//nor_512_267 (out_512 vdd norout512_267 vdd vss PBulkLine NBulkLine) twonor
//nor_512_268 (out_512 vdd norout512_268 vdd vss PBulkLine NBulkLine) twonor
//nor_512_269 (out_512 vdd norout512_269 vdd vss PBulkLine NBulkLine) twonor
//nor_512_270 (out_512 vdd norout512_270 vdd vss PBulkLine NBulkLine) twonor
//nor_512_271 (out_512 vdd norout512_271 vdd vss PBulkLine NBulkLine) twonor
//nor_512_272 (out_512 vdd norout512_272 vdd vss PBulkLine NBulkLine) twonor
//nor_512_273 (out_512 vdd norout512_273 vdd vss PBulkLine NBulkLine) twonor
//nor_512_274 (out_512 vdd norout512_274 vdd vss PBulkLine NBulkLine) twonor
//nor_512_275 (out_512 vdd norout512_275 vdd vss PBulkLine NBulkLine) twonor
//nor_512_276 (out_512 vdd norout512_276 vdd vss PBulkLine NBulkLine) twonor
//nor_512_277 (out_512 vdd norout512_277 vdd vss PBulkLine NBulkLine) twonor
//nor_512_278 (out_512 vdd norout512_278 vdd vss PBulkLine NBulkLine) twonor
//nor_512_279 (out_512 vdd norout512_279 vdd vss PBulkLine NBulkLine) twonor
//nor_512_280 (out_512 vdd norout512_280 vdd vss PBulkLine NBulkLine) twonor
//nor_512_281 (out_512 vdd norout512_281 vdd vss PBulkLine NBulkLine) twonor
//nor_512_282 (out_512 vdd norout512_282 vdd vss PBulkLine NBulkLine) twonor
//nor_512_283 (out_512 vdd norout512_283 vdd vss PBulkLine NBulkLine) twonor
//nor_512_284 (out_512 vdd norout512_284 vdd vss PBulkLine NBulkLine) twonor
//nor_512_285 (out_512 vdd norout512_285 vdd vss PBulkLine NBulkLine) twonor
//nor_512_286 (out_512 vdd norout512_286 vdd vss PBulkLine NBulkLine) twonor
//nor_512_287 (out_512 vdd norout512_287 vdd vss PBulkLine NBulkLine) twonor
//nor_512_288 (out_512 vdd norout512_288 vdd vss PBulkLine NBulkLine) twonor
//nor_512_289 (out_512 vdd norout512_289 vdd vss PBulkLine NBulkLine) twonor
//nor_512_290 (out_512 vdd norout512_290 vdd vss PBulkLine NBulkLine) twonor
//nor_512_291 (out_512 vdd norout512_291 vdd vss PBulkLine NBulkLine) twonor
//nor_512_292 (out_512 vdd norout512_292 vdd vss PBulkLine NBulkLine) twonor
//nor_512_293 (out_512 vdd norout512_293 vdd vss PBulkLine NBulkLine) twonor
//nor_512_294 (out_512 vdd norout512_294 vdd vss PBulkLine NBulkLine) twonor
//nor_512_295 (out_512 vdd norout512_295 vdd vss PBulkLine NBulkLine) twonor
//nor_512_296 (out_512 vdd norout512_296 vdd vss PBulkLine NBulkLine) twonor
//nor_512_297 (out_512 vdd norout512_297 vdd vss PBulkLine NBulkLine) twonor
//nor_512_298 (out_512 vdd norout512_298 vdd vss PBulkLine NBulkLine) twonor
//nor_512_299 (out_512 vdd norout512_299 vdd vss PBulkLine NBulkLine) twonor
//nor_512_300 (out_512 vdd norout512_300 vdd vss PBulkLine NBulkLine) twonor
//nor_512_301 (out_512 vdd norout512_301 vdd vss PBulkLine NBulkLine) twonor
//nor_512_302 (out_512 vdd norout512_302 vdd vss PBulkLine NBulkLine) twonor
//nor_512_303 (out_512 vdd norout512_303 vdd vss PBulkLine NBulkLine) twonor
//nor_512_304 (out_512 vdd norout512_304 vdd vss PBulkLine NBulkLine) twonor
//nor_512_305 (out_512 vdd norout512_305 vdd vss PBulkLine NBulkLine) twonor
//nor_512_306 (out_512 vdd norout512_306 vdd vss PBulkLine NBulkLine) twonor
//nor_512_307 (out_512 vdd norout512_307 vdd vss PBulkLine NBulkLine) twonor
//nor_512_308 (out_512 vdd norout512_308 vdd vss PBulkLine NBulkLine) twonor
//nor_512_309 (out_512 vdd norout512_309 vdd vss PBulkLine NBulkLine) twonor
//nor_512_310 (out_512 vdd norout512_310 vdd vss PBulkLine NBulkLine) twonor
//nor_512_311 (out_512 vdd norout512_311 vdd vss PBulkLine NBulkLine) twonor
//nor_512_312 (out_512 vdd norout512_312 vdd vss PBulkLine NBulkLine) twonor
//nor_512_313 (out_512 vdd norout512_313 vdd vss PBulkLine NBulkLine) twonor
//nor_512_314 (out_512 vdd norout512_314 vdd vss PBulkLine NBulkLine) twonor
//nor_512_315 (out_512 vdd norout512_315 vdd vss PBulkLine NBulkLine) twonor
//nor_512_316 (out_512 vdd norout512_316 vdd vss PBulkLine NBulkLine) twonor
//nor_512_317 (out_512 vdd norout512_317 vdd vss PBulkLine NBulkLine) twonor
//nor_512_318 (out_512 vdd norout512_318 vdd vss PBulkLine NBulkLine) twonor
//nor_512_319 (out_512 vdd norout512_319 vdd vss PBulkLine NBulkLine) twonor
//nor_512_320 (out_512 vdd norout512_320 vdd vss PBulkLine NBulkLine) twonor
//nor_512_321 (out_512 vdd norout512_321 vdd vss PBulkLine NBulkLine) twonor
//nor_512_322 (out_512 vdd norout512_322 vdd vss PBulkLine NBulkLine) twonor
//nor_512_323 (out_512 vdd norout512_323 vdd vss PBulkLine NBulkLine) twonor
//nor_512_324 (out_512 vdd norout512_324 vdd vss PBulkLine NBulkLine) twonor
//nor_512_325 (out_512 vdd norout512_325 vdd vss PBulkLine NBulkLine) twonor
//nor_512_326 (out_512 vdd norout512_326 vdd vss PBulkLine NBulkLine) twonor
//nor_512_327 (out_512 vdd norout512_327 vdd vss PBulkLine NBulkLine) twonor
//nor_512_328 (out_512 vdd norout512_328 vdd vss PBulkLine NBulkLine) twonor
//nor_512_329 (out_512 vdd norout512_329 vdd vss PBulkLine NBulkLine) twonor
//nor_512_330 (out_512 vdd norout512_330 vdd vss PBulkLine NBulkLine) twonor
//nor_512_331 (out_512 vdd norout512_331 vdd vss PBulkLine NBulkLine) twonor
//nor_512_332 (out_512 vdd norout512_332 vdd vss PBulkLine NBulkLine) twonor
//nor_512_333 (out_512 vdd norout512_333 vdd vss PBulkLine NBulkLine) twonor
//nor_512_334 (out_512 vdd norout512_334 vdd vss PBulkLine NBulkLine) twonor
//nor_512_335 (out_512 vdd norout512_335 vdd vss PBulkLine NBulkLine) twonor
//nor_512_336 (out_512 vdd norout512_336 vdd vss PBulkLine NBulkLine) twonor
//nor_512_337 (out_512 vdd norout512_337 vdd vss PBulkLine NBulkLine) twonor
//nor_512_338 (out_512 vdd norout512_338 vdd vss PBulkLine NBulkLine) twonor
//nor_512_339 (out_512 vdd norout512_339 vdd vss PBulkLine NBulkLine) twonor
//nor_512_340 (out_512 vdd norout512_340 vdd vss PBulkLine NBulkLine) twonor
//nor_512_341 (out_512 vdd norout512_341 vdd vss PBulkLine NBulkLine) twonor
//nor_512_342 (out_512 vdd norout512_342 vdd vss PBulkLine NBulkLine) twonor
//nor_512_343 (out_512 vdd norout512_343 vdd vss PBulkLine NBulkLine) twonor
//nor_512_344 (out_512 vdd norout512_344 vdd vss PBulkLine NBulkLine) twonor
//nor_512_345 (out_512 vdd norout512_345 vdd vss PBulkLine NBulkLine) twonor
//nor_512_346 (out_512 vdd norout512_346 vdd vss PBulkLine NBulkLine) twonor
//nor_512_347 (out_512 vdd norout512_347 vdd vss PBulkLine NBulkLine) twonor
//nor_512_348 (out_512 vdd norout512_348 vdd vss PBulkLine NBulkLine) twonor
//nor_512_349 (out_512 vdd norout512_349 vdd vss PBulkLine NBulkLine) twonor
//nor_512_350 (out_512 vdd norout512_350 vdd vss PBulkLine NBulkLine) twonor
//nor_512_351 (out_512 vdd norout512_351 vdd vss PBulkLine NBulkLine) twonor
//nor_512_352 (out_512 vdd norout512_352 vdd vss PBulkLine NBulkLine) twonor
//nor_512_353 (out_512 vdd norout512_353 vdd vss PBulkLine NBulkLine) twonor
//nor_512_354 (out_512 vdd norout512_354 vdd vss PBulkLine NBulkLine) twonor
//nor_512_355 (out_512 vdd norout512_355 vdd vss PBulkLine NBulkLine) twonor
//nor_512_356 (out_512 vdd norout512_356 vdd vss PBulkLine NBulkLine) twonor
//nor_512_357 (out_512 vdd norout512_357 vdd vss PBulkLine NBulkLine) twonor
//nor_512_358 (out_512 vdd norout512_358 vdd vss PBulkLine NBulkLine) twonor
//nor_512_359 (out_512 vdd norout512_359 vdd vss PBulkLine NBulkLine) twonor
//nor_512_360 (out_512 vdd norout512_360 vdd vss PBulkLine NBulkLine) twonor
//nor_512_361 (out_512 vdd norout512_361 vdd vss PBulkLine NBulkLine) twonor
//nor_512_362 (out_512 vdd norout512_362 vdd vss PBulkLine NBulkLine) twonor
//nor_512_363 (out_512 vdd norout512_363 vdd vss PBulkLine NBulkLine) twonor
//nor_512_364 (out_512 vdd norout512_364 vdd vss PBulkLine NBulkLine) twonor
//nor_512_365 (out_512 vdd norout512_365 vdd vss PBulkLine NBulkLine) twonor
//nor_512_366 (out_512 vdd norout512_366 vdd vss PBulkLine NBulkLine) twonor
//nor_512_367 (out_512 vdd norout512_367 vdd vss PBulkLine NBulkLine) twonor
//nor_512_368 (out_512 vdd norout512_368 vdd vss PBulkLine NBulkLine) twonor
//nor_512_369 (out_512 vdd norout512_369 vdd vss PBulkLine NBulkLine) twonor
//nor_512_370 (out_512 vdd norout512_370 vdd vss PBulkLine NBulkLine) twonor
//nor_512_371 (out_512 vdd norout512_371 vdd vss PBulkLine NBulkLine) twonor
//nor_512_372 (out_512 vdd norout512_372 vdd vss PBulkLine NBulkLine) twonor
//nor_512_373 (out_512 vdd norout512_373 vdd vss PBulkLine NBulkLine) twonor
//nor_512_374 (out_512 vdd norout512_374 vdd vss PBulkLine NBulkLine) twonor
//nor_512_375 (out_512 vdd norout512_375 vdd vss PBulkLine NBulkLine) twonor
//nor_512_376 (out_512 vdd norout512_376 vdd vss PBulkLine NBulkLine) twonor
//nor_512_377 (out_512 vdd norout512_377 vdd vss PBulkLine NBulkLine) twonor
//nor_512_378 (out_512 vdd norout512_378 vdd vss PBulkLine NBulkLine) twonor
//nor_512_379 (out_512 vdd norout512_379 vdd vss PBulkLine NBulkLine) twonor
//nor_512_380 (out_512 vdd norout512_380 vdd vss PBulkLine NBulkLine) twonor
//nor_512_381 (out_512 vdd norout512_381 vdd vss PBulkLine NBulkLine) twonor
//nor_512_382 (out_512 vdd norout512_382 vdd vss PBulkLine NBulkLine) twonor
//nor_512_383 (out_512 vdd norout512_383 vdd vss PBulkLine NBulkLine) twonor
//nor_512_384 (out_512 vdd norout512_384 vdd vss PBulkLine NBulkLine) twonor
//nor_512_385 (out_512 vdd norout512_385 vdd vss PBulkLine NBulkLine) twonor
//nor_512_386 (out_512 vdd norout512_386 vdd vss PBulkLine NBulkLine) twonor
//nor_512_387 (out_512 vdd norout512_387 vdd vss PBulkLine NBulkLine) twonor
//nor_512_388 (out_512 vdd norout512_388 vdd vss PBulkLine NBulkLine) twonor
//nor_512_389 (out_512 vdd norout512_389 vdd vss PBulkLine NBulkLine) twonor
//nor_512_390 (out_512 vdd norout512_390 vdd vss PBulkLine NBulkLine) twonor
//nor_512_391 (out_512 vdd norout512_391 vdd vss PBulkLine NBulkLine) twonor
//nor_512_392 (out_512 vdd norout512_392 vdd vss PBulkLine NBulkLine) twonor
//nor_512_393 (out_512 vdd norout512_393 vdd vss PBulkLine NBulkLine) twonor
//nor_512_394 (out_512 vdd norout512_394 vdd vss PBulkLine NBulkLine) twonor
//nor_512_395 (out_512 vdd norout512_395 vdd vss PBulkLine NBulkLine) twonor
//nor_512_396 (out_512 vdd norout512_396 vdd vss PBulkLine NBulkLine) twonor
//nor_512_397 (out_512 vdd norout512_397 vdd vss PBulkLine NBulkLine) twonor
//nor_512_398 (out_512 vdd norout512_398 vdd vss PBulkLine NBulkLine) twonor
//nor_512_399 (out_512 vdd norout512_399 vdd vss PBulkLine NBulkLine) twonor
//nor_512_400 (out_512 vdd norout512_400 vdd vss PBulkLine NBulkLine) twonor
//nor_512_401 (out_512 vdd norout512_401 vdd vss PBulkLine NBulkLine) twonor
//nor_512_402 (out_512 vdd norout512_402 vdd vss PBulkLine NBulkLine) twonor
//nor_512_403 (out_512 vdd norout512_403 vdd vss PBulkLine NBulkLine) twonor
//nor_512_404 (out_512 vdd norout512_404 vdd vss PBulkLine NBulkLine) twonor
//nor_512_405 (out_512 vdd norout512_405 vdd vss PBulkLine NBulkLine) twonor
//nor_512_406 (out_512 vdd norout512_406 vdd vss PBulkLine NBulkLine) twonor
//nor_512_407 (out_512 vdd norout512_407 vdd vss PBulkLine NBulkLine) twonor
//nor_512_408 (out_512 vdd norout512_408 vdd vss PBulkLine NBulkLine) twonor
//nor_512_409 (out_512 vdd norout512_409 vdd vss PBulkLine NBulkLine) twonor
//nor_512_410 (out_512 vdd norout512_410 vdd vss PBulkLine NBulkLine) twonor
//nor_512_411 (out_512 vdd norout512_411 vdd vss PBulkLine NBulkLine) twonor
//nor_512_412 (out_512 vdd norout512_412 vdd vss PBulkLine NBulkLine) twonor
//nor_512_413 (out_512 vdd norout512_413 vdd vss PBulkLine NBulkLine) twonor
//nor_512_414 (out_512 vdd norout512_414 vdd vss PBulkLine NBulkLine) twonor
//nor_512_415 (out_512 vdd norout512_415 vdd vss PBulkLine NBulkLine) twonor
//nor_512_416 (out_512 vdd norout512_416 vdd vss PBulkLine NBulkLine) twonor
//nor_512_417 (out_512 vdd norout512_417 vdd vss PBulkLine NBulkLine) twonor
//nor_512_418 (out_512 vdd norout512_418 vdd vss PBulkLine NBulkLine) twonor
//nor_512_419 (out_512 vdd norout512_419 vdd vss PBulkLine NBulkLine) twonor
//nor_512_420 (out_512 vdd norout512_420 vdd vss PBulkLine NBulkLine) twonor
//nor_512_421 (out_512 vdd norout512_421 vdd vss PBulkLine NBulkLine) twonor
//nor_512_422 (out_512 vdd norout512_422 vdd vss PBulkLine NBulkLine) twonor
//nor_512_423 (out_512 vdd norout512_423 vdd vss PBulkLine NBulkLine) twonor
//nor_512_424 (out_512 vdd norout512_424 vdd vss PBulkLine NBulkLine) twonor
//nor_512_425 (out_512 vdd norout512_425 vdd vss PBulkLine NBulkLine) twonor
//nor_512_426 (out_512 vdd norout512_426 vdd vss PBulkLine NBulkLine) twonor
//nor_512_427 (out_512 vdd norout512_427 vdd vss PBulkLine NBulkLine) twonor
//nor_512_428 (out_512 vdd norout512_428 vdd vss PBulkLine NBulkLine) twonor
//nor_512_429 (out_512 vdd norout512_429 vdd vss PBulkLine NBulkLine) twonor
//nor_512_430 (out_512 vdd norout512_430 vdd vss PBulkLine NBulkLine) twonor
//nor_512_431 (out_512 vdd norout512_431 vdd vss PBulkLine NBulkLine) twonor
//nor_512_432 (out_512 vdd norout512_432 vdd vss PBulkLine NBulkLine) twonor
//nor_512_433 (out_512 vdd norout512_433 vdd vss PBulkLine NBulkLine) twonor
//nor_512_434 (out_512 vdd norout512_434 vdd vss PBulkLine NBulkLine) twonor
//nor_512_435 (out_512 vdd norout512_435 vdd vss PBulkLine NBulkLine) twonor
//nor_512_436 (out_512 vdd norout512_436 vdd vss PBulkLine NBulkLine) twonor
//nor_512_437 (out_512 vdd norout512_437 vdd vss PBulkLine NBulkLine) twonor
//nor_512_438 (out_512 vdd norout512_438 vdd vss PBulkLine NBulkLine) twonor
//nor_512_439 (out_512 vdd norout512_439 vdd vss PBulkLine NBulkLine) twonor
//nor_512_440 (out_512 vdd norout512_440 vdd vss PBulkLine NBulkLine) twonor
//nor_512_441 (out_512 vdd norout512_441 vdd vss PBulkLine NBulkLine) twonor
//nor_512_442 (out_512 vdd norout512_442 vdd vss PBulkLine NBulkLine) twonor
//nor_512_443 (out_512 vdd norout512_443 vdd vss PBulkLine NBulkLine) twonor
//nor_512_444 (out_512 vdd norout512_444 vdd vss PBulkLine NBulkLine) twonor
//nor_512_445 (out_512 vdd norout512_445 vdd vss PBulkLine NBulkLine) twonor
//nor_512_446 (out_512 vdd norout512_446 vdd vss PBulkLine NBulkLine) twonor
//nor_512_447 (out_512 vdd norout512_447 vdd vss PBulkLine NBulkLine) twonor
//nor_512_448 (out_512 vdd norout512_448 vdd vss PBulkLine NBulkLine) twonor
//nor_512_449 (out_512 vdd norout512_449 vdd vss PBulkLine NBulkLine) twonor
//nor_512_450 (out_512 vdd norout512_450 vdd vss PBulkLine NBulkLine) twonor
//nor_512_451 (out_512 vdd norout512_451 vdd vss PBulkLine NBulkLine) twonor
//nor_512_452 (out_512 vdd norout512_452 vdd vss PBulkLine NBulkLine) twonor
//nor_512_453 (out_512 vdd norout512_453 vdd vss PBulkLine NBulkLine) twonor
//nor_512_454 (out_512 vdd norout512_454 vdd vss PBulkLine NBulkLine) twonor
//nor_512_455 (out_512 vdd norout512_455 vdd vss PBulkLine NBulkLine) twonor
//nor_512_456 (out_512 vdd norout512_456 vdd vss PBulkLine NBulkLine) twonor
//nor_512_457 (out_512 vdd norout512_457 vdd vss PBulkLine NBulkLine) twonor
//nor_512_458 (out_512 vdd norout512_458 vdd vss PBulkLine NBulkLine) twonor
//nor_512_459 (out_512 vdd norout512_459 vdd vss PBulkLine NBulkLine) twonor
//nor_512_460 (out_512 vdd norout512_460 vdd vss PBulkLine NBulkLine) twonor
//nor_512_461 (out_512 vdd norout512_461 vdd vss PBulkLine NBulkLine) twonor
//nor_512_462 (out_512 vdd norout512_462 vdd vss PBulkLine NBulkLine) twonor
//nor_512_463 (out_512 vdd norout512_463 vdd vss PBulkLine NBulkLine) twonor
//nor_512_464 (out_512 vdd norout512_464 vdd vss PBulkLine NBulkLine) twonor
//nor_512_465 (out_512 vdd norout512_465 vdd vss PBulkLine NBulkLine) twonor
//nor_512_466 (out_512 vdd norout512_466 vdd vss PBulkLine NBulkLine) twonor
//nor_512_467 (out_512 vdd norout512_467 vdd vss PBulkLine NBulkLine) twonor
//nor_512_468 (out_512 vdd norout512_468 vdd vss PBulkLine NBulkLine) twonor
//nor_512_469 (out_512 vdd norout512_469 vdd vss PBulkLine NBulkLine) twonor
//nor_512_470 (out_512 vdd norout512_470 vdd vss PBulkLine NBulkLine) twonor
//nor_512_471 (out_512 vdd norout512_471 vdd vss PBulkLine NBulkLine) twonor
//nor_512_472 (out_512 vdd norout512_472 vdd vss PBulkLine NBulkLine) twonor
//nor_512_473 (out_512 vdd norout512_473 vdd vss PBulkLine NBulkLine) twonor
//nor_512_474 (out_512 vdd norout512_474 vdd vss PBulkLine NBulkLine) twonor
//nor_512_475 (out_512 vdd norout512_475 vdd vss PBulkLine NBulkLine) twonor
//nor_512_476 (out_512 vdd norout512_476 vdd vss PBulkLine NBulkLine) twonor
//nor_512_477 (out_512 vdd norout512_477 vdd vss PBulkLine NBulkLine) twonor
//nor_512_478 (out_512 vdd norout512_478 vdd vss PBulkLine NBulkLine) twonor
//nor_512_479 (out_512 vdd norout512_479 vdd vss PBulkLine NBulkLine) twonor
//nor_512_480 (out_512 vdd norout512_480 vdd vss PBulkLine NBulkLine) twonor
//nor_512_481 (out_512 vdd norout512_481 vdd vss PBulkLine NBulkLine) twonor
//nor_512_482 (out_512 vdd norout512_482 vdd vss PBulkLine NBulkLine) twonor
//nor_512_483 (out_512 vdd norout512_483 vdd vss PBulkLine NBulkLine) twonor
//nor_512_484 (out_512 vdd norout512_484 vdd vss PBulkLine NBulkLine) twonor
//nor_512_485 (out_512 vdd norout512_485 vdd vss PBulkLine NBulkLine) twonor
//nor_512_486 (out_512 vdd norout512_486 vdd vss PBulkLine NBulkLine) twonor
//nor_512_487 (out_512 vdd norout512_487 vdd vss PBulkLine NBulkLine) twonor
//nor_512_488 (out_512 vdd norout512_488 vdd vss PBulkLine NBulkLine) twonor
//nor_512_489 (out_512 vdd norout512_489 vdd vss PBulkLine NBulkLine) twonor
//nor_512_490 (out_512 vdd norout512_490 vdd vss PBulkLine NBulkLine) twonor
//nor_512_491 (out_512 vdd norout512_491 vdd vss PBulkLine NBulkLine) twonor
//nor_512_492 (out_512 vdd norout512_492 vdd vss PBulkLine NBulkLine) twonor
//nor_512_493 (out_512 vdd norout512_493 vdd vss PBulkLine NBulkLine) twonor
//nor_512_494 (out_512 vdd norout512_494 vdd vss PBulkLine NBulkLine) twonor
//nor_512_495 (out_512 vdd norout512_495 vdd vss PBulkLine NBulkLine) twonor
//nor_512_496 (out_512 vdd norout512_496 vdd vss PBulkLine NBulkLine) twonor
//nor_512_497 (out_512 vdd norout512_497 vdd vss PBulkLine NBulkLine) twonor
//nor_512_498 (out_512 vdd norout512_498 vdd vss PBulkLine NBulkLine) twonor
//nor_512_499 (out_512 vdd norout512_499 vdd vss PBulkLine NBulkLine) twonor
//nor_512_500 (out_512 vdd norout512_500 vdd vss PBulkLine NBulkLine) twonor
//nor_512_501 (out_512 vdd norout512_501 vdd vss PBulkLine NBulkLine) twonor
//nor_512_502 (out_512 vdd norout512_502 vdd vss PBulkLine NBulkLine) twonor
//nor_512_503 (out_512 vdd norout512_503 vdd vss PBulkLine NBulkLine) twonor
//nor_512_504 (out_512 vdd norout512_504 vdd vss PBulkLine NBulkLine) twonor
//nor_512_505 (out_512 vdd norout512_505 vdd vss PBulkLine NBulkLine) twonor
//nor_512_506 (out_512 vdd norout512_506 vdd vss PBulkLine NBulkLine) twonor
//nor_512_507 (out_512 vdd norout512_507 vdd vss PBulkLine NBulkLine) twonor
//nor_512_508 (out_512 vdd norout512_508 vdd vss PBulkLine NBulkLine) twonor
//nor_512_509 (out_512 vdd norout512_509 vdd vss PBulkLine NBulkLine) twonor
//nor_512_510 (out_512 vdd norout512_510 vdd vss PBulkLine NBulkLine) twonor
//nor_512_511 (out_512 vdd norout512_511 vdd vss PBulkLine NBulkLine) twonor
//nor_512_512 (out_512 vdd norout512_512 vdd vss PBulkLine NBulkLine) twonor
cPar_512 out_512 vss capacitor c=9.216e-14
xbuffer_1024 (vdd vss vss vdd in out_1024) buffer_INVNOR_onethousandtwentyfour
//nor_1024_1 (out_1024 vdd norout1024_1 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_2 (out_1024 vdd norout1024_2 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_3 (out_1024 vdd norout1024_3 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_4 (out_1024 vdd norout1024_4 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_5 (out_1024 vdd norout1024_5 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_6 (out_1024 vdd norout1024_6 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_7 (out_1024 vdd norout1024_7 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_8 (out_1024 vdd norout1024_8 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_9 (out_1024 vdd norout1024_9 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_10 (out_1024 vdd norout1024_10 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_11 (out_1024 vdd norout1024_11 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_12 (out_1024 vdd norout1024_12 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_13 (out_1024 vdd norout1024_13 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_14 (out_1024 vdd norout1024_14 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_15 (out_1024 vdd norout1024_15 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_16 (out_1024 vdd norout1024_16 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_17 (out_1024 vdd norout1024_17 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_18 (out_1024 vdd norout1024_18 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_19 (out_1024 vdd norout1024_19 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_20 (out_1024 vdd norout1024_20 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_21 (out_1024 vdd norout1024_21 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_22 (out_1024 vdd norout1024_22 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_23 (out_1024 vdd norout1024_23 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_24 (out_1024 vdd norout1024_24 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_25 (out_1024 vdd norout1024_25 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_26 (out_1024 vdd norout1024_26 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_27 (out_1024 vdd norout1024_27 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_28 (out_1024 vdd norout1024_28 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_29 (out_1024 vdd norout1024_29 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_30 (out_1024 vdd norout1024_30 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_31 (out_1024 vdd norout1024_31 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_32 (out_1024 vdd norout1024_32 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_33 (out_1024 vdd norout1024_33 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_34 (out_1024 vdd norout1024_34 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_35 (out_1024 vdd norout1024_35 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_36 (out_1024 vdd norout1024_36 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_37 (out_1024 vdd norout1024_37 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_38 (out_1024 vdd norout1024_38 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_39 (out_1024 vdd norout1024_39 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_40 (out_1024 vdd norout1024_40 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_41 (out_1024 vdd norout1024_41 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_42 (out_1024 vdd norout1024_42 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_43 (out_1024 vdd norout1024_43 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_44 (out_1024 vdd norout1024_44 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_45 (out_1024 vdd norout1024_45 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_46 (out_1024 vdd norout1024_46 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_47 (out_1024 vdd norout1024_47 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_48 (out_1024 vdd norout1024_48 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_49 (out_1024 vdd norout1024_49 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_50 (out_1024 vdd norout1024_50 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_51 (out_1024 vdd norout1024_51 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_52 (out_1024 vdd norout1024_52 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_53 (out_1024 vdd norout1024_53 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_54 (out_1024 vdd norout1024_54 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_55 (out_1024 vdd norout1024_55 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_56 (out_1024 vdd norout1024_56 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_57 (out_1024 vdd norout1024_57 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_58 (out_1024 vdd norout1024_58 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_59 (out_1024 vdd norout1024_59 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_60 (out_1024 vdd norout1024_60 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_61 (out_1024 vdd norout1024_61 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_62 (out_1024 vdd norout1024_62 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_63 (out_1024 vdd norout1024_63 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_64 (out_1024 vdd norout1024_64 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_65 (out_1024 vdd norout1024_65 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_66 (out_1024 vdd norout1024_66 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_67 (out_1024 vdd norout1024_67 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_68 (out_1024 vdd norout1024_68 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_69 (out_1024 vdd norout1024_69 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_70 (out_1024 vdd norout1024_70 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_71 (out_1024 vdd norout1024_71 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_72 (out_1024 vdd norout1024_72 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_73 (out_1024 vdd norout1024_73 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_74 (out_1024 vdd norout1024_74 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_75 (out_1024 vdd norout1024_75 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_76 (out_1024 vdd norout1024_76 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_77 (out_1024 vdd norout1024_77 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_78 (out_1024 vdd norout1024_78 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_79 (out_1024 vdd norout1024_79 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_80 (out_1024 vdd norout1024_80 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_81 (out_1024 vdd norout1024_81 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_82 (out_1024 vdd norout1024_82 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_83 (out_1024 vdd norout1024_83 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_84 (out_1024 vdd norout1024_84 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_85 (out_1024 vdd norout1024_85 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_86 (out_1024 vdd norout1024_86 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_87 (out_1024 vdd norout1024_87 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_88 (out_1024 vdd norout1024_88 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_89 (out_1024 vdd norout1024_89 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_90 (out_1024 vdd norout1024_90 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_91 (out_1024 vdd norout1024_91 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_92 (out_1024 vdd norout1024_92 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_93 (out_1024 vdd norout1024_93 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_94 (out_1024 vdd norout1024_94 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_95 (out_1024 vdd norout1024_95 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_96 (out_1024 vdd norout1024_96 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_97 (out_1024 vdd norout1024_97 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_98 (out_1024 vdd norout1024_98 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_99 (out_1024 vdd norout1024_99 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_100 (out_1024 vdd norout1024_100 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_101 (out_1024 vdd norout1024_101 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_102 (out_1024 vdd norout1024_102 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_103 (out_1024 vdd norout1024_103 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_104 (out_1024 vdd norout1024_104 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_105 (out_1024 vdd norout1024_105 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_106 (out_1024 vdd norout1024_106 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_107 (out_1024 vdd norout1024_107 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_108 (out_1024 vdd norout1024_108 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_109 (out_1024 vdd norout1024_109 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_110 (out_1024 vdd norout1024_110 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_111 (out_1024 vdd norout1024_111 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_112 (out_1024 vdd norout1024_112 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_113 (out_1024 vdd norout1024_113 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_114 (out_1024 vdd norout1024_114 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_115 (out_1024 vdd norout1024_115 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_116 (out_1024 vdd norout1024_116 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_117 (out_1024 vdd norout1024_117 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_118 (out_1024 vdd norout1024_118 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_119 (out_1024 vdd norout1024_119 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_120 (out_1024 vdd norout1024_120 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_121 (out_1024 vdd norout1024_121 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_122 (out_1024 vdd norout1024_122 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_123 (out_1024 vdd norout1024_123 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_124 (out_1024 vdd norout1024_124 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_125 (out_1024 vdd norout1024_125 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_126 (out_1024 vdd norout1024_126 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_127 (out_1024 vdd norout1024_127 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_128 (out_1024 vdd norout1024_128 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_129 (out_1024 vdd norout1024_129 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_130 (out_1024 vdd norout1024_130 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_131 (out_1024 vdd norout1024_131 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_132 (out_1024 vdd norout1024_132 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_133 (out_1024 vdd norout1024_133 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_134 (out_1024 vdd norout1024_134 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_135 (out_1024 vdd norout1024_135 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_136 (out_1024 vdd norout1024_136 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_137 (out_1024 vdd norout1024_137 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_138 (out_1024 vdd norout1024_138 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_139 (out_1024 vdd norout1024_139 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_140 (out_1024 vdd norout1024_140 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_141 (out_1024 vdd norout1024_141 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_142 (out_1024 vdd norout1024_142 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_143 (out_1024 vdd norout1024_143 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_144 (out_1024 vdd norout1024_144 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_145 (out_1024 vdd norout1024_145 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_146 (out_1024 vdd norout1024_146 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_147 (out_1024 vdd norout1024_147 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_148 (out_1024 vdd norout1024_148 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_149 (out_1024 vdd norout1024_149 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_150 (out_1024 vdd norout1024_150 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_151 (out_1024 vdd norout1024_151 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_152 (out_1024 vdd norout1024_152 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_153 (out_1024 vdd norout1024_153 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_154 (out_1024 vdd norout1024_154 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_155 (out_1024 vdd norout1024_155 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_156 (out_1024 vdd norout1024_156 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_157 (out_1024 vdd norout1024_157 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_158 (out_1024 vdd norout1024_158 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_159 (out_1024 vdd norout1024_159 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_160 (out_1024 vdd norout1024_160 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_161 (out_1024 vdd norout1024_161 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_162 (out_1024 vdd norout1024_162 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_163 (out_1024 vdd norout1024_163 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_164 (out_1024 vdd norout1024_164 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_165 (out_1024 vdd norout1024_165 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_166 (out_1024 vdd norout1024_166 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_167 (out_1024 vdd norout1024_167 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_168 (out_1024 vdd norout1024_168 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_169 (out_1024 vdd norout1024_169 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_170 (out_1024 vdd norout1024_170 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_171 (out_1024 vdd norout1024_171 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_172 (out_1024 vdd norout1024_172 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_173 (out_1024 vdd norout1024_173 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_174 (out_1024 vdd norout1024_174 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_175 (out_1024 vdd norout1024_175 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_176 (out_1024 vdd norout1024_176 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_177 (out_1024 vdd norout1024_177 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_178 (out_1024 vdd norout1024_178 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_179 (out_1024 vdd norout1024_179 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_180 (out_1024 vdd norout1024_180 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_181 (out_1024 vdd norout1024_181 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_182 (out_1024 vdd norout1024_182 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_183 (out_1024 vdd norout1024_183 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_184 (out_1024 vdd norout1024_184 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_185 (out_1024 vdd norout1024_185 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_186 (out_1024 vdd norout1024_186 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_187 (out_1024 vdd norout1024_187 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_188 (out_1024 vdd norout1024_188 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_189 (out_1024 vdd norout1024_189 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_190 (out_1024 vdd norout1024_190 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_191 (out_1024 vdd norout1024_191 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_192 (out_1024 vdd norout1024_192 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_193 (out_1024 vdd norout1024_193 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_194 (out_1024 vdd norout1024_194 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_195 (out_1024 vdd norout1024_195 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_196 (out_1024 vdd norout1024_196 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_197 (out_1024 vdd norout1024_197 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_198 (out_1024 vdd norout1024_198 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_199 (out_1024 vdd norout1024_199 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_200 (out_1024 vdd norout1024_200 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_201 (out_1024 vdd norout1024_201 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_202 (out_1024 vdd norout1024_202 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_203 (out_1024 vdd norout1024_203 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_204 (out_1024 vdd norout1024_204 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_205 (out_1024 vdd norout1024_205 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_206 (out_1024 vdd norout1024_206 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_207 (out_1024 vdd norout1024_207 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_208 (out_1024 vdd norout1024_208 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_209 (out_1024 vdd norout1024_209 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_210 (out_1024 vdd norout1024_210 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_211 (out_1024 vdd norout1024_211 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_212 (out_1024 vdd norout1024_212 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_213 (out_1024 vdd norout1024_213 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_214 (out_1024 vdd norout1024_214 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_215 (out_1024 vdd norout1024_215 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_216 (out_1024 vdd norout1024_216 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_217 (out_1024 vdd norout1024_217 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_218 (out_1024 vdd norout1024_218 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_219 (out_1024 vdd norout1024_219 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_220 (out_1024 vdd norout1024_220 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_221 (out_1024 vdd norout1024_221 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_222 (out_1024 vdd norout1024_222 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_223 (out_1024 vdd norout1024_223 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_224 (out_1024 vdd norout1024_224 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_225 (out_1024 vdd norout1024_225 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_226 (out_1024 vdd norout1024_226 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_227 (out_1024 vdd norout1024_227 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_228 (out_1024 vdd norout1024_228 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_229 (out_1024 vdd norout1024_229 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_230 (out_1024 vdd norout1024_230 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_231 (out_1024 vdd norout1024_231 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_232 (out_1024 vdd norout1024_232 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_233 (out_1024 vdd norout1024_233 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_234 (out_1024 vdd norout1024_234 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_235 (out_1024 vdd norout1024_235 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_236 (out_1024 vdd norout1024_236 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_237 (out_1024 vdd norout1024_237 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_238 (out_1024 vdd norout1024_238 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_239 (out_1024 vdd norout1024_239 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_240 (out_1024 vdd norout1024_240 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_241 (out_1024 vdd norout1024_241 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_242 (out_1024 vdd norout1024_242 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_243 (out_1024 vdd norout1024_243 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_244 (out_1024 vdd norout1024_244 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_245 (out_1024 vdd norout1024_245 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_246 (out_1024 vdd norout1024_246 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_247 (out_1024 vdd norout1024_247 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_248 (out_1024 vdd norout1024_248 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_249 (out_1024 vdd norout1024_249 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_250 (out_1024 vdd norout1024_250 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_251 (out_1024 vdd norout1024_251 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_252 (out_1024 vdd norout1024_252 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_253 (out_1024 vdd norout1024_253 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_254 (out_1024 vdd norout1024_254 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_255 (out_1024 vdd norout1024_255 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_256 (out_1024 vdd norout1024_256 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_257 (out_1024 vdd norout1024_257 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_258 (out_1024 vdd norout1024_258 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_259 (out_1024 vdd norout1024_259 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_260 (out_1024 vdd norout1024_260 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_261 (out_1024 vdd norout1024_261 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_262 (out_1024 vdd norout1024_262 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_263 (out_1024 vdd norout1024_263 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_264 (out_1024 vdd norout1024_264 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_265 (out_1024 vdd norout1024_265 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_266 (out_1024 vdd norout1024_266 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_267 (out_1024 vdd norout1024_267 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_268 (out_1024 vdd norout1024_268 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_269 (out_1024 vdd norout1024_269 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_270 (out_1024 vdd norout1024_270 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_271 (out_1024 vdd norout1024_271 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_272 (out_1024 vdd norout1024_272 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_273 (out_1024 vdd norout1024_273 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_274 (out_1024 vdd norout1024_274 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_275 (out_1024 vdd norout1024_275 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_276 (out_1024 vdd norout1024_276 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_277 (out_1024 vdd norout1024_277 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_278 (out_1024 vdd norout1024_278 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_279 (out_1024 vdd norout1024_279 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_280 (out_1024 vdd norout1024_280 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_281 (out_1024 vdd norout1024_281 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_282 (out_1024 vdd norout1024_282 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_283 (out_1024 vdd norout1024_283 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_284 (out_1024 vdd norout1024_284 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_285 (out_1024 vdd norout1024_285 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_286 (out_1024 vdd norout1024_286 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_287 (out_1024 vdd norout1024_287 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_288 (out_1024 vdd norout1024_288 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_289 (out_1024 vdd norout1024_289 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_290 (out_1024 vdd norout1024_290 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_291 (out_1024 vdd norout1024_291 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_292 (out_1024 vdd norout1024_292 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_293 (out_1024 vdd norout1024_293 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_294 (out_1024 vdd norout1024_294 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_295 (out_1024 vdd norout1024_295 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_296 (out_1024 vdd norout1024_296 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_297 (out_1024 vdd norout1024_297 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_298 (out_1024 vdd norout1024_298 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_299 (out_1024 vdd norout1024_299 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_300 (out_1024 vdd norout1024_300 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_301 (out_1024 vdd norout1024_301 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_302 (out_1024 vdd norout1024_302 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_303 (out_1024 vdd norout1024_303 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_304 (out_1024 vdd norout1024_304 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_305 (out_1024 vdd norout1024_305 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_306 (out_1024 vdd norout1024_306 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_307 (out_1024 vdd norout1024_307 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_308 (out_1024 vdd norout1024_308 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_309 (out_1024 vdd norout1024_309 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_310 (out_1024 vdd norout1024_310 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_311 (out_1024 vdd norout1024_311 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_312 (out_1024 vdd norout1024_312 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_313 (out_1024 vdd norout1024_313 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_314 (out_1024 vdd norout1024_314 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_315 (out_1024 vdd norout1024_315 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_316 (out_1024 vdd norout1024_316 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_317 (out_1024 vdd norout1024_317 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_318 (out_1024 vdd norout1024_318 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_319 (out_1024 vdd norout1024_319 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_320 (out_1024 vdd norout1024_320 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_321 (out_1024 vdd norout1024_321 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_322 (out_1024 vdd norout1024_322 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_323 (out_1024 vdd norout1024_323 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_324 (out_1024 vdd norout1024_324 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_325 (out_1024 vdd norout1024_325 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_326 (out_1024 vdd norout1024_326 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_327 (out_1024 vdd norout1024_327 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_328 (out_1024 vdd norout1024_328 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_329 (out_1024 vdd norout1024_329 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_330 (out_1024 vdd norout1024_330 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_331 (out_1024 vdd norout1024_331 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_332 (out_1024 vdd norout1024_332 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_333 (out_1024 vdd norout1024_333 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_334 (out_1024 vdd norout1024_334 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_335 (out_1024 vdd norout1024_335 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_336 (out_1024 vdd norout1024_336 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_337 (out_1024 vdd norout1024_337 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_338 (out_1024 vdd norout1024_338 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_339 (out_1024 vdd norout1024_339 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_340 (out_1024 vdd norout1024_340 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_341 (out_1024 vdd norout1024_341 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_342 (out_1024 vdd norout1024_342 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_343 (out_1024 vdd norout1024_343 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_344 (out_1024 vdd norout1024_344 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_345 (out_1024 vdd norout1024_345 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_346 (out_1024 vdd norout1024_346 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_347 (out_1024 vdd norout1024_347 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_348 (out_1024 vdd norout1024_348 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_349 (out_1024 vdd norout1024_349 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_350 (out_1024 vdd norout1024_350 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_351 (out_1024 vdd norout1024_351 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_352 (out_1024 vdd norout1024_352 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_353 (out_1024 vdd norout1024_353 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_354 (out_1024 vdd norout1024_354 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_355 (out_1024 vdd norout1024_355 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_356 (out_1024 vdd norout1024_356 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_357 (out_1024 vdd norout1024_357 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_358 (out_1024 vdd norout1024_358 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_359 (out_1024 vdd norout1024_359 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_360 (out_1024 vdd norout1024_360 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_361 (out_1024 vdd norout1024_361 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_362 (out_1024 vdd norout1024_362 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_363 (out_1024 vdd norout1024_363 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_364 (out_1024 vdd norout1024_364 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_365 (out_1024 vdd norout1024_365 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_366 (out_1024 vdd norout1024_366 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_367 (out_1024 vdd norout1024_367 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_368 (out_1024 vdd norout1024_368 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_369 (out_1024 vdd norout1024_369 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_370 (out_1024 vdd norout1024_370 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_371 (out_1024 vdd norout1024_371 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_372 (out_1024 vdd norout1024_372 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_373 (out_1024 vdd norout1024_373 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_374 (out_1024 vdd norout1024_374 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_375 (out_1024 vdd norout1024_375 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_376 (out_1024 vdd norout1024_376 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_377 (out_1024 vdd norout1024_377 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_378 (out_1024 vdd norout1024_378 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_379 (out_1024 vdd norout1024_379 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_380 (out_1024 vdd norout1024_380 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_381 (out_1024 vdd norout1024_381 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_382 (out_1024 vdd norout1024_382 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_383 (out_1024 vdd norout1024_383 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_384 (out_1024 vdd norout1024_384 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_385 (out_1024 vdd norout1024_385 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_386 (out_1024 vdd norout1024_386 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_387 (out_1024 vdd norout1024_387 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_388 (out_1024 vdd norout1024_388 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_389 (out_1024 vdd norout1024_389 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_390 (out_1024 vdd norout1024_390 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_391 (out_1024 vdd norout1024_391 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_392 (out_1024 vdd norout1024_392 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_393 (out_1024 vdd norout1024_393 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_394 (out_1024 vdd norout1024_394 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_395 (out_1024 vdd norout1024_395 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_396 (out_1024 vdd norout1024_396 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_397 (out_1024 vdd norout1024_397 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_398 (out_1024 vdd norout1024_398 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_399 (out_1024 vdd norout1024_399 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_400 (out_1024 vdd norout1024_400 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_401 (out_1024 vdd norout1024_401 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_402 (out_1024 vdd norout1024_402 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_403 (out_1024 vdd norout1024_403 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_404 (out_1024 vdd norout1024_404 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_405 (out_1024 vdd norout1024_405 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_406 (out_1024 vdd norout1024_406 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_407 (out_1024 vdd norout1024_407 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_408 (out_1024 vdd norout1024_408 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_409 (out_1024 vdd norout1024_409 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_410 (out_1024 vdd norout1024_410 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_411 (out_1024 vdd norout1024_411 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_412 (out_1024 vdd norout1024_412 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_413 (out_1024 vdd norout1024_413 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_414 (out_1024 vdd norout1024_414 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_415 (out_1024 vdd norout1024_415 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_416 (out_1024 vdd norout1024_416 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_417 (out_1024 vdd norout1024_417 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_418 (out_1024 vdd norout1024_418 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_419 (out_1024 vdd norout1024_419 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_420 (out_1024 vdd norout1024_420 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_421 (out_1024 vdd norout1024_421 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_422 (out_1024 vdd norout1024_422 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_423 (out_1024 vdd norout1024_423 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_424 (out_1024 vdd norout1024_424 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_425 (out_1024 vdd norout1024_425 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_426 (out_1024 vdd norout1024_426 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_427 (out_1024 vdd norout1024_427 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_428 (out_1024 vdd norout1024_428 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_429 (out_1024 vdd norout1024_429 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_430 (out_1024 vdd norout1024_430 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_431 (out_1024 vdd norout1024_431 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_432 (out_1024 vdd norout1024_432 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_433 (out_1024 vdd norout1024_433 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_434 (out_1024 vdd norout1024_434 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_435 (out_1024 vdd norout1024_435 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_436 (out_1024 vdd norout1024_436 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_437 (out_1024 vdd norout1024_437 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_438 (out_1024 vdd norout1024_438 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_439 (out_1024 vdd norout1024_439 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_440 (out_1024 vdd norout1024_440 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_441 (out_1024 vdd norout1024_441 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_442 (out_1024 vdd norout1024_442 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_443 (out_1024 vdd norout1024_443 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_444 (out_1024 vdd norout1024_444 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_445 (out_1024 vdd norout1024_445 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_446 (out_1024 vdd norout1024_446 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_447 (out_1024 vdd norout1024_447 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_448 (out_1024 vdd norout1024_448 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_449 (out_1024 vdd norout1024_449 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_450 (out_1024 vdd norout1024_450 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_451 (out_1024 vdd norout1024_451 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_452 (out_1024 vdd norout1024_452 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_453 (out_1024 vdd norout1024_453 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_454 (out_1024 vdd norout1024_454 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_455 (out_1024 vdd norout1024_455 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_456 (out_1024 vdd norout1024_456 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_457 (out_1024 vdd norout1024_457 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_458 (out_1024 vdd norout1024_458 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_459 (out_1024 vdd norout1024_459 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_460 (out_1024 vdd norout1024_460 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_461 (out_1024 vdd norout1024_461 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_462 (out_1024 vdd norout1024_462 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_463 (out_1024 vdd norout1024_463 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_464 (out_1024 vdd norout1024_464 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_465 (out_1024 vdd norout1024_465 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_466 (out_1024 vdd norout1024_466 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_467 (out_1024 vdd norout1024_467 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_468 (out_1024 vdd norout1024_468 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_469 (out_1024 vdd norout1024_469 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_470 (out_1024 vdd norout1024_470 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_471 (out_1024 vdd norout1024_471 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_472 (out_1024 vdd norout1024_472 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_473 (out_1024 vdd norout1024_473 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_474 (out_1024 vdd norout1024_474 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_475 (out_1024 vdd norout1024_475 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_476 (out_1024 vdd norout1024_476 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_477 (out_1024 vdd norout1024_477 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_478 (out_1024 vdd norout1024_478 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_479 (out_1024 vdd norout1024_479 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_480 (out_1024 vdd norout1024_480 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_481 (out_1024 vdd norout1024_481 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_482 (out_1024 vdd norout1024_482 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_483 (out_1024 vdd norout1024_483 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_484 (out_1024 vdd norout1024_484 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_485 (out_1024 vdd norout1024_485 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_486 (out_1024 vdd norout1024_486 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_487 (out_1024 vdd norout1024_487 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_488 (out_1024 vdd norout1024_488 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_489 (out_1024 vdd norout1024_489 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_490 (out_1024 vdd norout1024_490 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_491 (out_1024 vdd norout1024_491 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_492 (out_1024 vdd norout1024_492 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_493 (out_1024 vdd norout1024_493 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_494 (out_1024 vdd norout1024_494 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_495 (out_1024 vdd norout1024_495 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_496 (out_1024 vdd norout1024_496 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_497 (out_1024 vdd norout1024_497 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_498 (out_1024 vdd norout1024_498 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_499 (out_1024 vdd norout1024_499 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_500 (out_1024 vdd norout1024_500 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_501 (out_1024 vdd norout1024_501 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_502 (out_1024 vdd norout1024_502 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_503 (out_1024 vdd norout1024_503 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_504 (out_1024 vdd norout1024_504 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_505 (out_1024 vdd norout1024_505 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_506 (out_1024 vdd norout1024_506 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_507 (out_1024 vdd norout1024_507 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_508 (out_1024 vdd norout1024_508 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_509 (out_1024 vdd norout1024_509 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_510 (out_1024 vdd norout1024_510 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_511 (out_1024 vdd norout1024_511 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_512 (out_1024 vdd norout1024_512 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_513 (out_1024 vdd norout1024_513 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_514 (out_1024 vdd norout1024_514 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_515 (out_1024 vdd norout1024_515 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_516 (out_1024 vdd norout1024_516 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_517 (out_1024 vdd norout1024_517 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_518 (out_1024 vdd norout1024_518 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_519 (out_1024 vdd norout1024_519 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_520 (out_1024 vdd norout1024_520 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_521 (out_1024 vdd norout1024_521 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_522 (out_1024 vdd norout1024_522 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_523 (out_1024 vdd norout1024_523 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_524 (out_1024 vdd norout1024_524 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_525 (out_1024 vdd norout1024_525 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_526 (out_1024 vdd norout1024_526 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_527 (out_1024 vdd norout1024_527 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_528 (out_1024 vdd norout1024_528 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_529 (out_1024 vdd norout1024_529 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_530 (out_1024 vdd norout1024_530 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_531 (out_1024 vdd norout1024_531 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_532 (out_1024 vdd norout1024_532 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_533 (out_1024 vdd norout1024_533 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_534 (out_1024 vdd norout1024_534 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_535 (out_1024 vdd norout1024_535 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_536 (out_1024 vdd norout1024_536 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_537 (out_1024 vdd norout1024_537 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_538 (out_1024 vdd norout1024_538 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_539 (out_1024 vdd norout1024_539 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_540 (out_1024 vdd norout1024_540 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_541 (out_1024 vdd norout1024_541 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_542 (out_1024 vdd norout1024_542 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_543 (out_1024 vdd norout1024_543 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_544 (out_1024 vdd norout1024_544 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_545 (out_1024 vdd norout1024_545 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_546 (out_1024 vdd norout1024_546 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_547 (out_1024 vdd norout1024_547 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_548 (out_1024 vdd norout1024_548 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_549 (out_1024 vdd norout1024_549 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_550 (out_1024 vdd norout1024_550 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_551 (out_1024 vdd norout1024_551 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_552 (out_1024 vdd norout1024_552 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_553 (out_1024 vdd norout1024_553 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_554 (out_1024 vdd norout1024_554 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_555 (out_1024 vdd norout1024_555 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_556 (out_1024 vdd norout1024_556 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_557 (out_1024 vdd norout1024_557 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_558 (out_1024 vdd norout1024_558 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_559 (out_1024 vdd norout1024_559 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_560 (out_1024 vdd norout1024_560 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_561 (out_1024 vdd norout1024_561 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_562 (out_1024 vdd norout1024_562 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_563 (out_1024 vdd norout1024_563 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_564 (out_1024 vdd norout1024_564 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_565 (out_1024 vdd norout1024_565 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_566 (out_1024 vdd norout1024_566 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_567 (out_1024 vdd norout1024_567 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_568 (out_1024 vdd norout1024_568 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_569 (out_1024 vdd norout1024_569 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_570 (out_1024 vdd norout1024_570 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_571 (out_1024 vdd norout1024_571 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_572 (out_1024 vdd norout1024_572 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_573 (out_1024 vdd norout1024_573 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_574 (out_1024 vdd norout1024_574 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_575 (out_1024 vdd norout1024_575 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_576 (out_1024 vdd norout1024_576 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_577 (out_1024 vdd norout1024_577 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_578 (out_1024 vdd norout1024_578 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_579 (out_1024 vdd norout1024_579 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_580 (out_1024 vdd norout1024_580 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_581 (out_1024 vdd norout1024_581 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_582 (out_1024 vdd norout1024_582 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_583 (out_1024 vdd norout1024_583 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_584 (out_1024 vdd norout1024_584 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_585 (out_1024 vdd norout1024_585 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_586 (out_1024 vdd norout1024_586 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_587 (out_1024 vdd norout1024_587 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_588 (out_1024 vdd norout1024_588 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_589 (out_1024 vdd norout1024_589 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_590 (out_1024 vdd norout1024_590 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_591 (out_1024 vdd norout1024_591 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_592 (out_1024 vdd norout1024_592 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_593 (out_1024 vdd norout1024_593 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_594 (out_1024 vdd norout1024_594 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_595 (out_1024 vdd norout1024_595 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_596 (out_1024 vdd norout1024_596 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_597 (out_1024 vdd norout1024_597 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_598 (out_1024 vdd norout1024_598 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_599 (out_1024 vdd norout1024_599 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_600 (out_1024 vdd norout1024_600 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_601 (out_1024 vdd norout1024_601 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_602 (out_1024 vdd norout1024_602 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_603 (out_1024 vdd norout1024_603 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_604 (out_1024 vdd norout1024_604 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_605 (out_1024 vdd norout1024_605 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_606 (out_1024 vdd norout1024_606 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_607 (out_1024 vdd norout1024_607 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_608 (out_1024 vdd norout1024_608 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_609 (out_1024 vdd norout1024_609 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_610 (out_1024 vdd norout1024_610 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_611 (out_1024 vdd norout1024_611 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_612 (out_1024 vdd norout1024_612 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_613 (out_1024 vdd norout1024_613 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_614 (out_1024 vdd norout1024_614 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_615 (out_1024 vdd norout1024_615 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_616 (out_1024 vdd norout1024_616 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_617 (out_1024 vdd norout1024_617 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_618 (out_1024 vdd norout1024_618 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_619 (out_1024 vdd norout1024_619 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_620 (out_1024 vdd norout1024_620 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_621 (out_1024 vdd norout1024_621 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_622 (out_1024 vdd norout1024_622 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_623 (out_1024 vdd norout1024_623 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_624 (out_1024 vdd norout1024_624 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_625 (out_1024 vdd norout1024_625 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_626 (out_1024 vdd norout1024_626 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_627 (out_1024 vdd norout1024_627 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_628 (out_1024 vdd norout1024_628 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_629 (out_1024 vdd norout1024_629 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_630 (out_1024 vdd norout1024_630 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_631 (out_1024 vdd norout1024_631 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_632 (out_1024 vdd norout1024_632 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_633 (out_1024 vdd norout1024_633 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_634 (out_1024 vdd norout1024_634 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_635 (out_1024 vdd norout1024_635 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_636 (out_1024 vdd norout1024_636 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_637 (out_1024 vdd norout1024_637 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_638 (out_1024 vdd norout1024_638 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_639 (out_1024 vdd norout1024_639 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_640 (out_1024 vdd norout1024_640 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_641 (out_1024 vdd norout1024_641 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_642 (out_1024 vdd norout1024_642 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_643 (out_1024 vdd norout1024_643 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_644 (out_1024 vdd norout1024_644 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_645 (out_1024 vdd norout1024_645 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_646 (out_1024 vdd norout1024_646 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_647 (out_1024 vdd norout1024_647 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_648 (out_1024 vdd norout1024_648 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_649 (out_1024 vdd norout1024_649 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_650 (out_1024 vdd norout1024_650 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_651 (out_1024 vdd norout1024_651 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_652 (out_1024 vdd norout1024_652 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_653 (out_1024 vdd norout1024_653 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_654 (out_1024 vdd norout1024_654 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_655 (out_1024 vdd norout1024_655 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_656 (out_1024 vdd norout1024_656 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_657 (out_1024 vdd norout1024_657 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_658 (out_1024 vdd norout1024_658 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_659 (out_1024 vdd norout1024_659 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_660 (out_1024 vdd norout1024_660 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_661 (out_1024 vdd norout1024_661 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_662 (out_1024 vdd norout1024_662 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_663 (out_1024 vdd norout1024_663 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_664 (out_1024 vdd norout1024_664 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_665 (out_1024 vdd norout1024_665 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_666 (out_1024 vdd norout1024_666 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_667 (out_1024 vdd norout1024_667 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_668 (out_1024 vdd norout1024_668 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_669 (out_1024 vdd norout1024_669 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_670 (out_1024 vdd norout1024_670 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_671 (out_1024 vdd norout1024_671 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_672 (out_1024 vdd norout1024_672 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_673 (out_1024 vdd norout1024_673 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_674 (out_1024 vdd norout1024_674 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_675 (out_1024 vdd norout1024_675 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_676 (out_1024 vdd norout1024_676 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_677 (out_1024 vdd norout1024_677 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_678 (out_1024 vdd norout1024_678 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_679 (out_1024 vdd norout1024_679 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_680 (out_1024 vdd norout1024_680 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_681 (out_1024 vdd norout1024_681 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_682 (out_1024 vdd norout1024_682 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_683 (out_1024 vdd norout1024_683 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_684 (out_1024 vdd norout1024_684 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_685 (out_1024 vdd norout1024_685 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_686 (out_1024 vdd norout1024_686 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_687 (out_1024 vdd norout1024_687 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_688 (out_1024 vdd norout1024_688 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_689 (out_1024 vdd norout1024_689 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_690 (out_1024 vdd norout1024_690 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_691 (out_1024 vdd norout1024_691 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_692 (out_1024 vdd norout1024_692 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_693 (out_1024 vdd norout1024_693 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_694 (out_1024 vdd norout1024_694 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_695 (out_1024 vdd norout1024_695 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_696 (out_1024 vdd norout1024_696 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_697 (out_1024 vdd norout1024_697 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_698 (out_1024 vdd norout1024_698 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_699 (out_1024 vdd norout1024_699 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_700 (out_1024 vdd norout1024_700 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_701 (out_1024 vdd norout1024_701 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_702 (out_1024 vdd norout1024_702 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_703 (out_1024 vdd norout1024_703 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_704 (out_1024 vdd norout1024_704 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_705 (out_1024 vdd norout1024_705 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_706 (out_1024 vdd norout1024_706 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_707 (out_1024 vdd norout1024_707 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_708 (out_1024 vdd norout1024_708 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_709 (out_1024 vdd norout1024_709 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_710 (out_1024 vdd norout1024_710 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_711 (out_1024 vdd norout1024_711 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_712 (out_1024 vdd norout1024_712 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_713 (out_1024 vdd norout1024_713 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_714 (out_1024 vdd norout1024_714 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_715 (out_1024 vdd norout1024_715 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_716 (out_1024 vdd norout1024_716 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_717 (out_1024 vdd norout1024_717 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_718 (out_1024 vdd norout1024_718 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_719 (out_1024 vdd norout1024_719 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_720 (out_1024 vdd norout1024_720 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_721 (out_1024 vdd norout1024_721 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_722 (out_1024 vdd norout1024_722 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_723 (out_1024 vdd norout1024_723 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_724 (out_1024 vdd norout1024_724 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_725 (out_1024 vdd norout1024_725 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_726 (out_1024 vdd norout1024_726 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_727 (out_1024 vdd norout1024_727 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_728 (out_1024 vdd norout1024_728 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_729 (out_1024 vdd norout1024_729 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_730 (out_1024 vdd norout1024_730 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_731 (out_1024 vdd norout1024_731 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_732 (out_1024 vdd norout1024_732 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_733 (out_1024 vdd norout1024_733 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_734 (out_1024 vdd norout1024_734 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_735 (out_1024 vdd norout1024_735 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_736 (out_1024 vdd norout1024_736 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_737 (out_1024 vdd norout1024_737 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_738 (out_1024 vdd norout1024_738 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_739 (out_1024 vdd norout1024_739 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_740 (out_1024 vdd norout1024_740 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_741 (out_1024 vdd norout1024_741 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_742 (out_1024 vdd norout1024_742 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_743 (out_1024 vdd norout1024_743 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_744 (out_1024 vdd norout1024_744 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_745 (out_1024 vdd norout1024_745 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_746 (out_1024 vdd norout1024_746 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_747 (out_1024 vdd norout1024_747 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_748 (out_1024 vdd norout1024_748 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_749 (out_1024 vdd norout1024_749 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_750 (out_1024 vdd norout1024_750 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_751 (out_1024 vdd norout1024_751 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_752 (out_1024 vdd norout1024_752 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_753 (out_1024 vdd norout1024_753 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_754 (out_1024 vdd norout1024_754 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_755 (out_1024 vdd norout1024_755 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_756 (out_1024 vdd norout1024_756 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_757 (out_1024 vdd norout1024_757 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_758 (out_1024 vdd norout1024_758 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_759 (out_1024 vdd norout1024_759 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_760 (out_1024 vdd norout1024_760 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_761 (out_1024 vdd norout1024_761 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_762 (out_1024 vdd norout1024_762 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_763 (out_1024 vdd norout1024_763 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_764 (out_1024 vdd norout1024_764 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_765 (out_1024 vdd norout1024_765 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_766 (out_1024 vdd norout1024_766 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_767 (out_1024 vdd norout1024_767 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_768 (out_1024 vdd norout1024_768 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_769 (out_1024 vdd norout1024_769 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_770 (out_1024 vdd norout1024_770 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_771 (out_1024 vdd norout1024_771 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_772 (out_1024 vdd norout1024_772 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_773 (out_1024 vdd norout1024_773 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_774 (out_1024 vdd norout1024_774 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_775 (out_1024 vdd norout1024_775 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_776 (out_1024 vdd norout1024_776 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_777 (out_1024 vdd norout1024_777 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_778 (out_1024 vdd norout1024_778 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_779 (out_1024 vdd norout1024_779 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_780 (out_1024 vdd norout1024_780 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_781 (out_1024 vdd norout1024_781 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_782 (out_1024 vdd norout1024_782 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_783 (out_1024 vdd norout1024_783 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_784 (out_1024 vdd norout1024_784 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_785 (out_1024 vdd norout1024_785 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_786 (out_1024 vdd norout1024_786 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_787 (out_1024 vdd norout1024_787 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_788 (out_1024 vdd norout1024_788 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_789 (out_1024 vdd norout1024_789 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_790 (out_1024 vdd norout1024_790 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_791 (out_1024 vdd norout1024_791 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_792 (out_1024 vdd norout1024_792 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_793 (out_1024 vdd norout1024_793 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_794 (out_1024 vdd norout1024_794 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_795 (out_1024 vdd norout1024_795 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_796 (out_1024 vdd norout1024_796 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_797 (out_1024 vdd norout1024_797 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_798 (out_1024 vdd norout1024_798 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_799 (out_1024 vdd norout1024_799 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_800 (out_1024 vdd norout1024_800 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_801 (out_1024 vdd norout1024_801 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_802 (out_1024 vdd norout1024_802 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_803 (out_1024 vdd norout1024_803 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_804 (out_1024 vdd norout1024_804 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_805 (out_1024 vdd norout1024_805 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_806 (out_1024 vdd norout1024_806 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_807 (out_1024 vdd norout1024_807 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_808 (out_1024 vdd norout1024_808 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_809 (out_1024 vdd norout1024_809 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_810 (out_1024 vdd norout1024_810 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_811 (out_1024 vdd norout1024_811 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_812 (out_1024 vdd norout1024_812 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_813 (out_1024 vdd norout1024_813 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_814 (out_1024 vdd norout1024_814 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_815 (out_1024 vdd norout1024_815 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_816 (out_1024 vdd norout1024_816 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_817 (out_1024 vdd norout1024_817 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_818 (out_1024 vdd norout1024_818 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_819 (out_1024 vdd norout1024_819 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_820 (out_1024 vdd norout1024_820 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_821 (out_1024 vdd norout1024_821 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_822 (out_1024 vdd norout1024_822 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_823 (out_1024 vdd norout1024_823 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_824 (out_1024 vdd norout1024_824 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_825 (out_1024 vdd norout1024_825 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_826 (out_1024 vdd norout1024_826 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_827 (out_1024 vdd norout1024_827 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_828 (out_1024 vdd norout1024_828 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_829 (out_1024 vdd norout1024_829 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_830 (out_1024 vdd norout1024_830 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_831 (out_1024 vdd norout1024_831 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_832 (out_1024 vdd norout1024_832 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_833 (out_1024 vdd norout1024_833 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_834 (out_1024 vdd norout1024_834 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_835 (out_1024 vdd norout1024_835 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_836 (out_1024 vdd norout1024_836 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_837 (out_1024 vdd norout1024_837 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_838 (out_1024 vdd norout1024_838 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_839 (out_1024 vdd norout1024_839 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_840 (out_1024 vdd norout1024_840 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_841 (out_1024 vdd norout1024_841 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_842 (out_1024 vdd norout1024_842 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_843 (out_1024 vdd norout1024_843 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_844 (out_1024 vdd norout1024_844 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_845 (out_1024 vdd norout1024_845 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_846 (out_1024 vdd norout1024_846 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_847 (out_1024 vdd norout1024_847 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_848 (out_1024 vdd norout1024_848 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_849 (out_1024 vdd norout1024_849 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_850 (out_1024 vdd norout1024_850 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_851 (out_1024 vdd norout1024_851 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_852 (out_1024 vdd norout1024_852 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_853 (out_1024 vdd norout1024_853 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_854 (out_1024 vdd norout1024_854 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_855 (out_1024 vdd norout1024_855 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_856 (out_1024 vdd norout1024_856 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_857 (out_1024 vdd norout1024_857 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_858 (out_1024 vdd norout1024_858 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_859 (out_1024 vdd norout1024_859 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_860 (out_1024 vdd norout1024_860 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_861 (out_1024 vdd norout1024_861 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_862 (out_1024 vdd norout1024_862 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_863 (out_1024 vdd norout1024_863 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_864 (out_1024 vdd norout1024_864 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_865 (out_1024 vdd norout1024_865 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_866 (out_1024 vdd norout1024_866 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_867 (out_1024 vdd norout1024_867 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_868 (out_1024 vdd norout1024_868 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_869 (out_1024 vdd norout1024_869 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_870 (out_1024 vdd norout1024_870 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_871 (out_1024 vdd norout1024_871 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_872 (out_1024 vdd norout1024_872 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_873 (out_1024 vdd norout1024_873 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_874 (out_1024 vdd norout1024_874 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_875 (out_1024 vdd norout1024_875 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_876 (out_1024 vdd norout1024_876 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_877 (out_1024 vdd norout1024_877 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_878 (out_1024 vdd norout1024_878 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_879 (out_1024 vdd norout1024_879 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_880 (out_1024 vdd norout1024_880 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_881 (out_1024 vdd norout1024_881 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_882 (out_1024 vdd norout1024_882 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_883 (out_1024 vdd norout1024_883 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_884 (out_1024 vdd norout1024_884 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_885 (out_1024 vdd norout1024_885 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_886 (out_1024 vdd norout1024_886 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_887 (out_1024 vdd norout1024_887 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_888 (out_1024 vdd norout1024_888 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_889 (out_1024 vdd norout1024_889 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_890 (out_1024 vdd norout1024_890 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_891 (out_1024 vdd norout1024_891 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_892 (out_1024 vdd norout1024_892 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_893 (out_1024 vdd norout1024_893 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_894 (out_1024 vdd norout1024_894 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_895 (out_1024 vdd norout1024_895 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_896 (out_1024 vdd norout1024_896 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_897 (out_1024 vdd norout1024_897 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_898 (out_1024 vdd norout1024_898 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_899 (out_1024 vdd norout1024_899 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_900 (out_1024 vdd norout1024_900 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_901 (out_1024 vdd norout1024_901 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_902 (out_1024 vdd norout1024_902 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_903 (out_1024 vdd norout1024_903 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_904 (out_1024 vdd norout1024_904 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_905 (out_1024 vdd norout1024_905 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_906 (out_1024 vdd norout1024_906 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_907 (out_1024 vdd norout1024_907 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_908 (out_1024 vdd norout1024_908 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_909 (out_1024 vdd norout1024_909 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_910 (out_1024 vdd norout1024_910 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_911 (out_1024 vdd norout1024_911 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_912 (out_1024 vdd norout1024_912 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_913 (out_1024 vdd norout1024_913 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_914 (out_1024 vdd norout1024_914 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_915 (out_1024 vdd norout1024_915 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_916 (out_1024 vdd norout1024_916 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_917 (out_1024 vdd norout1024_917 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_918 (out_1024 vdd norout1024_918 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_919 (out_1024 vdd norout1024_919 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_920 (out_1024 vdd norout1024_920 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_921 (out_1024 vdd norout1024_921 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_922 (out_1024 vdd norout1024_922 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_923 (out_1024 vdd norout1024_923 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_924 (out_1024 vdd norout1024_924 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_925 (out_1024 vdd norout1024_925 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_926 (out_1024 vdd norout1024_926 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_927 (out_1024 vdd norout1024_927 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_928 (out_1024 vdd norout1024_928 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_929 (out_1024 vdd norout1024_929 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_930 (out_1024 vdd norout1024_930 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_931 (out_1024 vdd norout1024_931 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_932 (out_1024 vdd norout1024_932 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_933 (out_1024 vdd norout1024_933 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_934 (out_1024 vdd norout1024_934 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_935 (out_1024 vdd norout1024_935 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_936 (out_1024 vdd norout1024_936 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_937 (out_1024 vdd norout1024_937 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_938 (out_1024 vdd norout1024_938 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_939 (out_1024 vdd norout1024_939 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_940 (out_1024 vdd norout1024_940 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_941 (out_1024 vdd norout1024_941 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_942 (out_1024 vdd norout1024_942 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_943 (out_1024 vdd norout1024_943 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_944 (out_1024 vdd norout1024_944 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_945 (out_1024 vdd norout1024_945 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_946 (out_1024 vdd norout1024_946 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_947 (out_1024 vdd norout1024_947 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_948 (out_1024 vdd norout1024_948 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_949 (out_1024 vdd norout1024_949 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_950 (out_1024 vdd norout1024_950 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_951 (out_1024 vdd norout1024_951 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_952 (out_1024 vdd norout1024_952 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_953 (out_1024 vdd norout1024_953 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_954 (out_1024 vdd norout1024_954 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_955 (out_1024 vdd norout1024_955 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_956 (out_1024 vdd norout1024_956 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_957 (out_1024 vdd norout1024_957 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_958 (out_1024 vdd norout1024_958 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_959 (out_1024 vdd norout1024_959 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_960 (out_1024 vdd norout1024_960 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_961 (out_1024 vdd norout1024_961 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_962 (out_1024 vdd norout1024_962 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_963 (out_1024 vdd norout1024_963 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_964 (out_1024 vdd norout1024_964 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_965 (out_1024 vdd norout1024_965 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_966 (out_1024 vdd norout1024_966 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_967 (out_1024 vdd norout1024_967 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_968 (out_1024 vdd norout1024_968 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_969 (out_1024 vdd norout1024_969 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_970 (out_1024 vdd norout1024_970 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_971 (out_1024 vdd norout1024_971 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_972 (out_1024 vdd norout1024_972 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_973 (out_1024 vdd norout1024_973 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_974 (out_1024 vdd norout1024_974 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_975 (out_1024 vdd norout1024_975 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_976 (out_1024 vdd norout1024_976 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_977 (out_1024 vdd norout1024_977 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_978 (out_1024 vdd norout1024_978 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_979 (out_1024 vdd norout1024_979 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_980 (out_1024 vdd norout1024_980 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_981 (out_1024 vdd norout1024_981 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_982 (out_1024 vdd norout1024_982 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_983 (out_1024 vdd norout1024_983 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_984 (out_1024 vdd norout1024_984 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_985 (out_1024 vdd norout1024_985 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_986 (out_1024 vdd norout1024_986 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_987 (out_1024 vdd norout1024_987 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_988 (out_1024 vdd norout1024_988 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_989 (out_1024 vdd norout1024_989 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_990 (out_1024 vdd norout1024_990 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_991 (out_1024 vdd norout1024_991 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_992 (out_1024 vdd norout1024_992 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_993 (out_1024 vdd norout1024_993 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_994 (out_1024 vdd norout1024_994 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_995 (out_1024 vdd norout1024_995 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_996 (out_1024 vdd norout1024_996 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_997 (out_1024 vdd norout1024_997 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_998 (out_1024 vdd norout1024_998 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_999 (out_1024 vdd norout1024_999 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1000 (out_1024 vdd norout1024_1000 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1001 (out_1024 vdd norout1024_1001 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1002 (out_1024 vdd norout1024_1002 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1003 (out_1024 vdd norout1024_1003 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1004 (out_1024 vdd norout1024_1004 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1005 (out_1024 vdd norout1024_1005 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1006 (out_1024 vdd norout1024_1006 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1007 (out_1024 vdd norout1024_1007 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1008 (out_1024 vdd norout1024_1008 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1009 (out_1024 vdd norout1024_1009 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1010 (out_1024 vdd norout1024_1010 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1011 (out_1024 vdd norout1024_1011 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1012 (out_1024 vdd norout1024_1012 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1013 (out_1024 vdd norout1024_1013 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1014 (out_1024 vdd norout1024_1014 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1015 (out_1024 vdd norout1024_1015 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1016 (out_1024 vdd norout1024_1016 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1017 (out_1024 vdd norout1024_1017 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1018 (out_1024 vdd norout1024_1018 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1019 (out_1024 vdd norout1024_1019 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1020 (out_1024 vdd norout1024_1020 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1021 (out_1024 vdd norout1024_1021 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1022 (out_1024 vdd norout1024_1022 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1023 (out_1024 vdd norout1024_1023 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1024 (out_1024 vdd norout1024_1024 vdd vss PBulkLine NBulkLine) twonor
cPar_1024 out_1024 vss capacitor c=1.8432e-13

ends buffer_sized

subckt buffer_notsized (vdd vss NBulkLine PBulkLine in out_8 out_16 out_32 out_64 out_128 out_256 out_512 out_1024)

xNot_8_a (in temp_8 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_8_b (temp_8 out_8 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_8_1 (out_8 vdd norout8_1 vdd vss PBulkLine NBulkLine) twonor
//nor_8_2 (out_8 vdd norout8_2 vdd vss PBulkLine NBulkLine) twonor
//nor_8_3 (out_8 vdd norout8_3 vdd vss PBulkLine NBulkLine) twonor
//nor_8_4 (out_8 vdd norout8_4 vdd vss PBulkLine NBulkLine) twonor
//nor_8_5 (out_8 vdd norout8_5 vdd vss PBulkLine NBulkLine) twonor
//nor_8_6 (out_8 vdd norout8_6 vdd vss PBulkLine NBulkLine) twonor
//nor_8_7 (out_8 vdd norout8_7 vdd vss PBulkLine NBulkLine) twonor
//nor_8_8 (out_8 vdd norout8_8 vdd vss PBulkLine NBulkLine) twonor
cPar_8 out_8 vss capacitor c=1.44e-15
xNot_16_a (in temp_16 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_16_b (temp_16 out_16 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_16_1 (out_16 vdd norout16_1 vdd vss PBulkLine NBulkLine) twonor
//nor_16_2 (out_16 vdd norout16_2 vdd vss PBulkLine NBulkLine) twonor
//nor_16_3 (out_16 vdd norout16_3 vdd vss PBulkLine NBulkLine) twonor
//nor_16_4 (out_16 vdd norout16_4 vdd vss PBulkLine NBulkLine) twonor
//nor_16_5 (out_16 vdd norout16_5 vdd vss PBulkLine NBulkLine) twonor
//nor_16_6 (out_16 vdd norout16_6 vdd vss PBulkLine NBulkLine) twonor
//nor_16_7 (out_16 vdd norout16_7 vdd vss PBulkLine NBulkLine) twonor
//nor_16_8 (out_16 vdd norout16_8 vdd vss PBulkLine NBulkLine) twonor
//nor_16_9 (out_16 vdd norout16_9 vdd vss PBulkLine NBulkLine) twonor
//nor_16_10 (out_16 vdd norout16_10 vdd vss PBulkLine NBulkLine) twonor
//nor_16_11 (out_16 vdd norout16_11 vdd vss PBulkLine NBulkLine) twonor
//nor_16_12 (out_16 vdd norout16_12 vdd vss PBulkLine NBulkLine) twonor
//nor_16_13 (out_16 vdd norout16_13 vdd vss PBulkLine NBulkLine) twonor
//nor_16_14 (out_16 vdd norout16_14 vdd vss PBulkLine NBulkLine) twonor
//nor_16_15 (out_16 vdd norout16_15 vdd vss PBulkLine NBulkLine) twonor
//nor_16_16 (out_16 vdd norout16_16 vdd vss PBulkLine NBulkLine) twonor
cPar_16 out_16 vss capacitor c=2.88e-15
xNot_32_a (in temp_32 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_32_b (temp_32 out_32 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_32_1 (out_32 vdd norout32_1 vdd vss PBulkLine NBulkLine) twonor
//nor_32_2 (out_32 vdd norout32_2 vdd vss PBulkLine NBulkLine) twonor
//nor_32_3 (out_32 vdd norout32_3 vdd vss PBulkLine NBulkLine) twonor
//nor_32_4 (out_32 vdd norout32_4 vdd vss PBulkLine NBulkLine) twonor
//nor_32_5 (out_32 vdd norout32_5 vdd vss PBulkLine NBulkLine) twonor
//nor_32_6 (out_32 vdd norout32_6 vdd vss PBulkLine NBulkLine) twonor
//nor_32_7 (out_32 vdd norout32_7 vdd vss PBulkLine NBulkLine) twonor
//nor_32_8 (out_32 vdd norout32_8 vdd vss PBulkLine NBulkLine) twonor
//nor_32_9 (out_32 vdd norout32_9 vdd vss PBulkLine NBulkLine) twonor
//nor_32_10 (out_32 vdd norout32_10 vdd vss PBulkLine NBulkLine) twonor
//nor_32_11 (out_32 vdd norout32_11 vdd vss PBulkLine NBulkLine) twonor
//nor_32_12 (out_32 vdd norout32_12 vdd vss PBulkLine NBulkLine) twonor
//nor_32_13 (out_32 vdd norout32_13 vdd vss PBulkLine NBulkLine) twonor
//nor_32_14 (out_32 vdd norout32_14 vdd vss PBulkLine NBulkLine) twonor
//nor_32_15 (out_32 vdd norout32_15 vdd vss PBulkLine NBulkLine) twonor
//nor_32_16 (out_32 vdd norout32_16 vdd vss PBulkLine NBulkLine) twonor
//nor_32_17 (out_32 vdd norout32_17 vdd vss PBulkLine NBulkLine) twonor
//nor_32_18 (out_32 vdd norout32_18 vdd vss PBulkLine NBulkLine) twonor
//nor_32_19 (out_32 vdd norout32_19 vdd vss PBulkLine NBulkLine) twonor
//nor_32_20 (out_32 vdd norout32_20 vdd vss PBulkLine NBulkLine) twonor
//nor_32_21 (out_32 vdd norout32_21 vdd vss PBulkLine NBulkLine) twonor
//nor_32_22 (out_32 vdd norout32_22 vdd vss PBulkLine NBulkLine) twonor
//nor_32_23 (out_32 vdd norout32_23 vdd vss PBulkLine NBulkLine) twonor
//nor_32_24 (out_32 vdd norout32_24 vdd vss PBulkLine NBulkLine) twonor
//nor_32_25 (out_32 vdd norout32_25 vdd vss PBulkLine NBulkLine) twonor
//nor_32_26 (out_32 vdd norout32_26 vdd vss PBulkLine NBulkLine) twonor
//nor_32_27 (out_32 vdd norout32_27 vdd vss PBulkLine NBulkLine) twonor
//nor_32_28 (out_32 vdd norout32_28 vdd vss PBulkLine NBulkLine) twonor
//nor_32_29 (out_32 vdd norout32_29 vdd vss PBulkLine NBulkLine) twonor
//nor_32_30 (out_32 vdd norout32_30 vdd vss PBulkLine NBulkLine) twonor
//nor_32_31 (out_32 vdd norout32_31 vdd vss PBulkLine NBulkLine) twonor
//nor_32_32 (out_32 vdd norout32_32 vdd vss PBulkLine NBulkLine) twonor
cPar_32 out_32 vss capacitor c=5.76e-15
xNot_64_a (in temp_64 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_64_b (temp_64 out_64 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_64_1 (out_64 vdd norout64_1 vdd vss PBulkLine NBulkLine) twonor
//nor_64_2 (out_64 vdd norout64_2 vdd vss PBulkLine NBulkLine) twonor
//nor_64_3 (out_64 vdd norout64_3 vdd vss PBulkLine NBulkLine) twonor
//nor_64_4 (out_64 vdd norout64_4 vdd vss PBulkLine NBulkLine) twonor
//nor_64_5 (out_64 vdd norout64_5 vdd vss PBulkLine NBulkLine) twonor
//nor_64_6 (out_64 vdd norout64_6 vdd vss PBulkLine NBulkLine) twonor
//nor_64_7 (out_64 vdd norout64_7 vdd vss PBulkLine NBulkLine) twonor
//nor_64_8 (out_64 vdd norout64_8 vdd vss PBulkLine NBulkLine) twonor
//nor_64_9 (out_64 vdd norout64_9 vdd vss PBulkLine NBulkLine) twonor
//nor_64_10 (out_64 vdd norout64_10 vdd vss PBulkLine NBulkLine) twonor
//nor_64_11 (out_64 vdd norout64_11 vdd vss PBulkLine NBulkLine) twonor
//nor_64_12 (out_64 vdd norout64_12 vdd vss PBulkLine NBulkLine) twonor
//nor_64_13 (out_64 vdd norout64_13 vdd vss PBulkLine NBulkLine) twonor
//nor_64_14 (out_64 vdd norout64_14 vdd vss PBulkLine NBulkLine) twonor
//nor_64_15 (out_64 vdd norout64_15 vdd vss PBulkLine NBulkLine) twonor
//nor_64_16 (out_64 vdd norout64_16 vdd vss PBulkLine NBulkLine) twonor
//nor_64_17 (out_64 vdd norout64_17 vdd vss PBulkLine NBulkLine) twonor
//nor_64_18 (out_64 vdd norout64_18 vdd vss PBulkLine NBulkLine) twonor
//nor_64_19 (out_64 vdd norout64_19 vdd vss PBulkLine NBulkLine) twonor
//nor_64_20 (out_64 vdd norout64_20 vdd vss PBulkLine NBulkLine) twonor
//nor_64_21 (out_64 vdd norout64_21 vdd vss PBulkLine NBulkLine) twonor
//nor_64_22 (out_64 vdd norout64_22 vdd vss PBulkLine NBulkLine) twonor
//nor_64_23 (out_64 vdd norout64_23 vdd vss PBulkLine NBulkLine) twonor
//nor_64_24 (out_64 vdd norout64_24 vdd vss PBulkLine NBulkLine) twonor
//nor_64_25 (out_64 vdd norout64_25 vdd vss PBulkLine NBulkLine) twonor
//nor_64_26 (out_64 vdd norout64_26 vdd vss PBulkLine NBulkLine) twonor
//nor_64_27 (out_64 vdd norout64_27 vdd vss PBulkLine NBulkLine) twonor
//nor_64_28 (out_64 vdd norout64_28 vdd vss PBulkLine NBulkLine) twonor
//nor_64_29 (out_64 vdd norout64_29 vdd vss PBulkLine NBulkLine) twonor
//nor_64_30 (out_64 vdd norout64_30 vdd vss PBulkLine NBulkLine) twonor
//nor_64_31 (out_64 vdd norout64_31 vdd vss PBulkLine NBulkLine) twonor
//nor_64_32 (out_64 vdd norout64_32 vdd vss PBulkLine NBulkLine) twonor
//nor_64_33 (out_64 vdd norout64_33 vdd vss PBulkLine NBulkLine) twonor
//nor_64_34 (out_64 vdd norout64_34 vdd vss PBulkLine NBulkLine) twonor
//nor_64_35 (out_64 vdd norout64_35 vdd vss PBulkLine NBulkLine) twonor
//nor_64_36 (out_64 vdd norout64_36 vdd vss PBulkLine NBulkLine) twonor
//nor_64_37 (out_64 vdd norout64_37 vdd vss PBulkLine NBulkLine) twonor
//nor_64_38 (out_64 vdd norout64_38 vdd vss PBulkLine NBulkLine) twonor
//nor_64_39 (out_64 vdd norout64_39 vdd vss PBulkLine NBulkLine) twonor
//nor_64_40 (out_64 vdd norout64_40 vdd vss PBulkLine NBulkLine) twonor
//nor_64_41 (out_64 vdd norout64_41 vdd vss PBulkLine NBulkLine) twonor
//nor_64_42 (out_64 vdd norout64_42 vdd vss PBulkLine NBulkLine) twonor
//nor_64_43 (out_64 vdd norout64_43 vdd vss PBulkLine NBulkLine) twonor
//nor_64_44 (out_64 vdd norout64_44 vdd vss PBulkLine NBulkLine) twonor
//nor_64_45 (out_64 vdd norout64_45 vdd vss PBulkLine NBulkLine) twonor
//nor_64_46 (out_64 vdd norout64_46 vdd vss PBulkLine NBulkLine) twonor
//nor_64_47 (out_64 vdd norout64_47 vdd vss PBulkLine NBulkLine) twonor
//nor_64_48 (out_64 vdd norout64_48 vdd vss PBulkLine NBulkLine) twonor
//nor_64_49 (out_64 vdd norout64_49 vdd vss PBulkLine NBulkLine) twonor
//nor_64_50 (out_64 vdd norout64_50 vdd vss PBulkLine NBulkLine) twonor
//nor_64_51 (out_64 vdd norout64_51 vdd vss PBulkLine NBulkLine) twonor
//nor_64_52 (out_64 vdd norout64_52 vdd vss PBulkLine NBulkLine) twonor
//nor_64_53 (out_64 vdd norout64_53 vdd vss PBulkLine NBulkLine) twonor
//nor_64_54 (out_64 vdd norout64_54 vdd vss PBulkLine NBulkLine) twonor
//nor_64_55 (out_64 vdd norout64_55 vdd vss PBulkLine NBulkLine) twonor
//nor_64_56 (out_64 vdd norout64_56 vdd vss PBulkLine NBulkLine) twonor
//nor_64_57 (out_64 vdd norout64_57 vdd vss PBulkLine NBulkLine) twonor
//nor_64_58 (out_64 vdd norout64_58 vdd vss PBulkLine NBulkLine) twonor
//nor_64_59 (out_64 vdd norout64_59 vdd vss PBulkLine NBulkLine) twonor
//nor_64_60 (out_64 vdd norout64_60 vdd vss PBulkLine NBulkLine) twonor
//nor_64_61 (out_64 vdd norout64_61 vdd vss PBulkLine NBulkLine) twonor
//nor_64_62 (out_64 vdd norout64_62 vdd vss PBulkLine NBulkLine) twonor
//nor_64_63 (out_64 vdd norout64_63 vdd vss PBulkLine NBulkLine) twonor
//nor_64_64 (out_64 vdd norout64_64 vdd vss PBulkLine NBulkLine) twonor
cPar_64 out_64 vss capacitor c=1.152e-14
xNot_128_a (in temp_128 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_128_b (temp_128 out_128 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_128_1 (out_128 vdd norout128_1 vdd vss PBulkLine NBulkLine) twonor
//nor_128_2 (out_128 vdd norout128_2 vdd vss PBulkLine NBulkLine) twonor
//nor_128_3 (out_128 vdd norout128_3 vdd vss PBulkLine NBulkLine) twonor
//nor_128_4 (out_128 vdd norout128_4 vdd vss PBulkLine NBulkLine) twonor
//nor_128_5 (out_128 vdd norout128_5 vdd vss PBulkLine NBulkLine) twonor
//nor_128_6 (out_128 vdd norout128_6 vdd vss PBulkLine NBulkLine) twonor
//nor_128_7 (out_128 vdd norout128_7 vdd vss PBulkLine NBulkLine) twonor
//nor_128_8 (out_128 vdd norout128_8 vdd vss PBulkLine NBulkLine) twonor
//nor_128_9 (out_128 vdd norout128_9 vdd vss PBulkLine NBulkLine) twonor
//nor_128_10 (out_128 vdd norout128_10 vdd vss PBulkLine NBulkLine) twonor
//nor_128_11 (out_128 vdd norout128_11 vdd vss PBulkLine NBulkLine) twonor
//nor_128_12 (out_128 vdd norout128_12 vdd vss PBulkLine NBulkLine) twonor
//nor_128_13 (out_128 vdd norout128_13 vdd vss PBulkLine NBulkLine) twonor
//nor_128_14 (out_128 vdd norout128_14 vdd vss PBulkLine NBulkLine) twonor
//nor_128_15 (out_128 vdd norout128_15 vdd vss PBulkLine NBulkLine) twonor
//nor_128_16 (out_128 vdd norout128_16 vdd vss PBulkLine NBulkLine) twonor
//nor_128_17 (out_128 vdd norout128_17 vdd vss PBulkLine NBulkLine) twonor
//nor_128_18 (out_128 vdd norout128_18 vdd vss PBulkLine NBulkLine) twonor
//nor_128_19 (out_128 vdd norout128_19 vdd vss PBulkLine NBulkLine) twonor
//nor_128_20 (out_128 vdd norout128_20 vdd vss PBulkLine NBulkLine) twonor
//nor_128_21 (out_128 vdd norout128_21 vdd vss PBulkLine NBulkLine) twonor
//nor_128_22 (out_128 vdd norout128_22 vdd vss PBulkLine NBulkLine) twonor
//nor_128_23 (out_128 vdd norout128_23 vdd vss PBulkLine NBulkLine) twonor
//nor_128_24 (out_128 vdd norout128_24 vdd vss PBulkLine NBulkLine) twonor
//nor_128_25 (out_128 vdd norout128_25 vdd vss PBulkLine NBulkLine) twonor
//nor_128_26 (out_128 vdd norout128_26 vdd vss PBulkLine NBulkLine) twonor
//nor_128_27 (out_128 vdd norout128_27 vdd vss PBulkLine NBulkLine) twonor
//nor_128_28 (out_128 vdd norout128_28 vdd vss PBulkLine NBulkLine) twonor
//nor_128_29 (out_128 vdd norout128_29 vdd vss PBulkLine NBulkLine) twonor
//nor_128_30 (out_128 vdd norout128_30 vdd vss PBulkLine NBulkLine) twonor
//nor_128_31 (out_128 vdd norout128_31 vdd vss PBulkLine NBulkLine) twonor
//nor_128_32 (out_128 vdd norout128_32 vdd vss PBulkLine NBulkLine) twonor
//nor_128_33 (out_128 vdd norout128_33 vdd vss PBulkLine NBulkLine) twonor
//nor_128_34 (out_128 vdd norout128_34 vdd vss PBulkLine NBulkLine) twonor
//nor_128_35 (out_128 vdd norout128_35 vdd vss PBulkLine NBulkLine) twonor
//nor_128_36 (out_128 vdd norout128_36 vdd vss PBulkLine NBulkLine) twonor
//nor_128_37 (out_128 vdd norout128_37 vdd vss PBulkLine NBulkLine) twonor
//nor_128_38 (out_128 vdd norout128_38 vdd vss PBulkLine NBulkLine) twonor
//nor_128_39 (out_128 vdd norout128_39 vdd vss PBulkLine NBulkLine) twonor
//nor_128_40 (out_128 vdd norout128_40 vdd vss PBulkLine NBulkLine) twonor
//nor_128_41 (out_128 vdd norout128_41 vdd vss PBulkLine NBulkLine) twonor
//nor_128_42 (out_128 vdd norout128_42 vdd vss PBulkLine NBulkLine) twonor
//nor_128_43 (out_128 vdd norout128_43 vdd vss PBulkLine NBulkLine) twonor
//nor_128_44 (out_128 vdd norout128_44 vdd vss PBulkLine NBulkLine) twonor
//nor_128_45 (out_128 vdd norout128_45 vdd vss PBulkLine NBulkLine) twonor
//nor_128_46 (out_128 vdd norout128_46 vdd vss PBulkLine NBulkLine) twonor
//nor_128_47 (out_128 vdd norout128_47 vdd vss PBulkLine NBulkLine) twonor
//nor_128_48 (out_128 vdd norout128_48 vdd vss PBulkLine NBulkLine) twonor
//nor_128_49 (out_128 vdd norout128_49 vdd vss PBulkLine NBulkLine) twonor
//nor_128_50 (out_128 vdd norout128_50 vdd vss PBulkLine NBulkLine) twonor
//nor_128_51 (out_128 vdd norout128_51 vdd vss PBulkLine NBulkLine) twonor
//nor_128_52 (out_128 vdd norout128_52 vdd vss PBulkLine NBulkLine) twonor
//nor_128_53 (out_128 vdd norout128_53 vdd vss PBulkLine NBulkLine) twonor
//nor_128_54 (out_128 vdd norout128_54 vdd vss PBulkLine NBulkLine) twonor
//nor_128_55 (out_128 vdd norout128_55 vdd vss PBulkLine NBulkLine) twonor
//nor_128_56 (out_128 vdd norout128_56 vdd vss PBulkLine NBulkLine) twonor
//nor_128_57 (out_128 vdd norout128_57 vdd vss PBulkLine NBulkLine) twonor
//nor_128_58 (out_128 vdd norout128_58 vdd vss PBulkLine NBulkLine) twonor
//nor_128_59 (out_128 vdd norout128_59 vdd vss PBulkLine NBulkLine) twonor
//nor_128_60 (out_128 vdd norout128_60 vdd vss PBulkLine NBulkLine) twonor
//nor_128_61 (out_128 vdd norout128_61 vdd vss PBulkLine NBulkLine) twonor
//nor_128_62 (out_128 vdd norout128_62 vdd vss PBulkLine NBulkLine) twonor
//nor_128_63 (out_128 vdd norout128_63 vdd vss PBulkLine NBulkLine) twonor
//nor_128_64 (out_128 vdd norout128_64 vdd vss PBulkLine NBulkLine) twonor
//nor_128_65 (out_128 vdd norout128_65 vdd vss PBulkLine NBulkLine) twonor
//nor_128_66 (out_128 vdd norout128_66 vdd vss PBulkLine NBulkLine) twonor
//nor_128_67 (out_128 vdd norout128_67 vdd vss PBulkLine NBulkLine) twonor
//nor_128_68 (out_128 vdd norout128_68 vdd vss PBulkLine NBulkLine) twonor
//nor_128_69 (out_128 vdd norout128_69 vdd vss PBulkLine NBulkLine) twonor
//nor_128_70 (out_128 vdd norout128_70 vdd vss PBulkLine NBulkLine) twonor
//nor_128_71 (out_128 vdd norout128_71 vdd vss PBulkLine NBulkLine) twonor
//nor_128_72 (out_128 vdd norout128_72 vdd vss PBulkLine NBulkLine) twonor
//nor_128_73 (out_128 vdd norout128_73 vdd vss PBulkLine NBulkLine) twonor
//nor_128_74 (out_128 vdd norout128_74 vdd vss PBulkLine NBulkLine) twonor
//nor_128_75 (out_128 vdd norout128_75 vdd vss PBulkLine NBulkLine) twonor
//nor_128_76 (out_128 vdd norout128_76 vdd vss PBulkLine NBulkLine) twonor
//nor_128_77 (out_128 vdd norout128_77 vdd vss PBulkLine NBulkLine) twonor
//nor_128_78 (out_128 vdd norout128_78 vdd vss PBulkLine NBulkLine) twonor
//nor_128_79 (out_128 vdd norout128_79 vdd vss PBulkLine NBulkLine) twonor
//nor_128_80 (out_128 vdd norout128_80 vdd vss PBulkLine NBulkLine) twonor
//nor_128_81 (out_128 vdd norout128_81 vdd vss PBulkLine NBulkLine) twonor
//nor_128_82 (out_128 vdd norout128_82 vdd vss PBulkLine NBulkLine) twonor
//nor_128_83 (out_128 vdd norout128_83 vdd vss PBulkLine NBulkLine) twonor
//nor_128_84 (out_128 vdd norout128_84 vdd vss PBulkLine NBulkLine) twonor
//nor_128_85 (out_128 vdd norout128_85 vdd vss PBulkLine NBulkLine) twonor
//nor_128_86 (out_128 vdd norout128_86 vdd vss PBulkLine NBulkLine) twonor
//nor_128_87 (out_128 vdd norout128_87 vdd vss PBulkLine NBulkLine) twonor
//nor_128_88 (out_128 vdd norout128_88 vdd vss PBulkLine NBulkLine) twonor
//nor_128_89 (out_128 vdd norout128_89 vdd vss PBulkLine NBulkLine) twonor
//nor_128_90 (out_128 vdd norout128_90 vdd vss PBulkLine NBulkLine) twonor
//nor_128_91 (out_128 vdd norout128_91 vdd vss PBulkLine NBulkLine) twonor
//nor_128_92 (out_128 vdd norout128_92 vdd vss PBulkLine NBulkLine) twonor
//nor_128_93 (out_128 vdd norout128_93 vdd vss PBulkLine NBulkLine) twonor
//nor_128_94 (out_128 vdd norout128_94 vdd vss PBulkLine NBulkLine) twonor
//nor_128_95 (out_128 vdd norout128_95 vdd vss PBulkLine NBulkLine) twonor
//nor_128_96 (out_128 vdd norout128_96 vdd vss PBulkLine NBulkLine) twonor
//nor_128_97 (out_128 vdd norout128_97 vdd vss PBulkLine NBulkLine) twonor
//nor_128_98 (out_128 vdd norout128_98 vdd vss PBulkLine NBulkLine) twonor
//nor_128_99 (out_128 vdd norout128_99 vdd vss PBulkLine NBulkLine) twonor
//nor_128_100 (out_128 vdd norout128_100 vdd vss PBulkLine NBulkLine) twonor
//nor_128_101 (out_128 vdd norout128_101 vdd vss PBulkLine NBulkLine) twonor
//nor_128_102 (out_128 vdd norout128_102 vdd vss PBulkLine NBulkLine) twonor
//nor_128_103 (out_128 vdd norout128_103 vdd vss PBulkLine NBulkLine) twonor
//nor_128_104 (out_128 vdd norout128_104 vdd vss PBulkLine NBulkLine) twonor
//nor_128_105 (out_128 vdd norout128_105 vdd vss PBulkLine NBulkLine) twonor
//nor_128_106 (out_128 vdd norout128_106 vdd vss PBulkLine NBulkLine) twonor
//nor_128_107 (out_128 vdd norout128_107 vdd vss PBulkLine NBulkLine) twonor
//nor_128_108 (out_128 vdd norout128_108 vdd vss PBulkLine NBulkLine) twonor
//nor_128_109 (out_128 vdd norout128_109 vdd vss PBulkLine NBulkLine) twonor
//nor_128_110 (out_128 vdd norout128_110 vdd vss PBulkLine NBulkLine) twonor
//nor_128_111 (out_128 vdd norout128_111 vdd vss PBulkLine NBulkLine) twonor
//nor_128_112 (out_128 vdd norout128_112 vdd vss PBulkLine NBulkLine) twonor
//nor_128_113 (out_128 vdd norout128_113 vdd vss PBulkLine NBulkLine) twonor
//nor_128_114 (out_128 vdd norout128_114 vdd vss PBulkLine NBulkLine) twonor
//nor_128_115 (out_128 vdd norout128_115 vdd vss PBulkLine NBulkLine) twonor
//nor_128_116 (out_128 vdd norout128_116 vdd vss PBulkLine NBulkLine) twonor
//nor_128_117 (out_128 vdd norout128_117 vdd vss PBulkLine NBulkLine) twonor
//nor_128_118 (out_128 vdd norout128_118 vdd vss PBulkLine NBulkLine) twonor
//nor_128_119 (out_128 vdd norout128_119 vdd vss PBulkLine NBulkLine) twonor
//nor_128_120 (out_128 vdd norout128_120 vdd vss PBulkLine NBulkLine) twonor
//nor_128_121 (out_128 vdd norout128_121 vdd vss PBulkLine NBulkLine) twonor
//nor_128_122 (out_128 vdd norout128_122 vdd vss PBulkLine NBulkLine) twonor
//nor_128_123 (out_128 vdd norout128_123 vdd vss PBulkLine NBulkLine) twonor
//nor_128_124 (out_128 vdd norout128_124 vdd vss PBulkLine NBulkLine) twonor
//nor_128_125 (out_128 vdd norout128_125 vdd vss PBulkLine NBulkLine) twonor
//nor_128_126 (out_128 vdd norout128_126 vdd vss PBulkLine NBulkLine) twonor
//nor_128_127 (out_128 vdd norout128_127 vdd vss PBulkLine NBulkLine) twonor
//nor_128_128 (out_128 vdd norout128_128 vdd vss PBulkLine NBulkLine) twonor
cPar_128 out_128 vss capacitor c=2.304e-14
xNot_256_a (in temp_256 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_256_b (temp_256 out_256 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_256_1 (out_256 vdd norout256_1 vdd vss PBulkLine NBulkLine) twonor
//nor_256_2 (out_256 vdd norout256_2 vdd vss PBulkLine NBulkLine) twonor
//nor_256_3 (out_256 vdd norout256_3 vdd vss PBulkLine NBulkLine) twonor
//nor_256_4 (out_256 vdd norout256_4 vdd vss PBulkLine NBulkLine) twonor
//nor_256_5 (out_256 vdd norout256_5 vdd vss PBulkLine NBulkLine) twonor
//nor_256_6 (out_256 vdd norout256_6 vdd vss PBulkLine NBulkLine) twonor
//nor_256_7 (out_256 vdd norout256_7 vdd vss PBulkLine NBulkLine) twonor
//nor_256_8 (out_256 vdd norout256_8 vdd vss PBulkLine NBulkLine) twonor
//nor_256_9 (out_256 vdd norout256_9 vdd vss PBulkLine NBulkLine) twonor
//nor_256_10 (out_256 vdd norout256_10 vdd vss PBulkLine NBulkLine) twonor
//nor_256_11 (out_256 vdd norout256_11 vdd vss PBulkLine NBulkLine) twonor
//nor_256_12 (out_256 vdd norout256_12 vdd vss PBulkLine NBulkLine) twonor
//nor_256_13 (out_256 vdd norout256_13 vdd vss PBulkLine NBulkLine) twonor
//nor_256_14 (out_256 vdd norout256_14 vdd vss PBulkLine NBulkLine) twonor
//nor_256_15 (out_256 vdd norout256_15 vdd vss PBulkLine NBulkLine) twonor
//nor_256_16 (out_256 vdd norout256_16 vdd vss PBulkLine NBulkLine) twonor
//nor_256_17 (out_256 vdd norout256_17 vdd vss PBulkLine NBulkLine) twonor
//nor_256_18 (out_256 vdd norout256_18 vdd vss PBulkLine NBulkLine) twonor
//nor_256_19 (out_256 vdd norout256_19 vdd vss PBulkLine NBulkLine) twonor
//nor_256_20 (out_256 vdd norout256_20 vdd vss PBulkLine NBulkLine) twonor
//nor_256_21 (out_256 vdd norout256_21 vdd vss PBulkLine NBulkLine) twonor
//nor_256_22 (out_256 vdd norout256_22 vdd vss PBulkLine NBulkLine) twonor
//nor_256_23 (out_256 vdd norout256_23 vdd vss PBulkLine NBulkLine) twonor
//nor_256_24 (out_256 vdd norout256_24 vdd vss PBulkLine NBulkLine) twonor
//nor_256_25 (out_256 vdd norout256_25 vdd vss PBulkLine NBulkLine) twonor
//nor_256_26 (out_256 vdd norout256_26 vdd vss PBulkLine NBulkLine) twonor
//nor_256_27 (out_256 vdd norout256_27 vdd vss PBulkLine NBulkLine) twonor
//nor_256_28 (out_256 vdd norout256_28 vdd vss PBulkLine NBulkLine) twonor
//nor_256_29 (out_256 vdd norout256_29 vdd vss PBulkLine NBulkLine) twonor
//nor_256_30 (out_256 vdd norout256_30 vdd vss PBulkLine NBulkLine) twonor
//nor_256_31 (out_256 vdd norout256_31 vdd vss PBulkLine NBulkLine) twonor
//nor_256_32 (out_256 vdd norout256_32 vdd vss PBulkLine NBulkLine) twonor
//nor_256_33 (out_256 vdd norout256_33 vdd vss PBulkLine NBulkLine) twonor
//nor_256_34 (out_256 vdd norout256_34 vdd vss PBulkLine NBulkLine) twonor
//nor_256_35 (out_256 vdd norout256_35 vdd vss PBulkLine NBulkLine) twonor
//nor_256_36 (out_256 vdd norout256_36 vdd vss PBulkLine NBulkLine) twonor
//nor_256_37 (out_256 vdd norout256_37 vdd vss PBulkLine NBulkLine) twonor
//nor_256_38 (out_256 vdd norout256_38 vdd vss PBulkLine NBulkLine) twonor
//nor_256_39 (out_256 vdd norout256_39 vdd vss PBulkLine NBulkLine) twonor
//nor_256_40 (out_256 vdd norout256_40 vdd vss PBulkLine NBulkLine) twonor
//nor_256_41 (out_256 vdd norout256_41 vdd vss PBulkLine NBulkLine) twonor
//nor_256_42 (out_256 vdd norout256_42 vdd vss PBulkLine NBulkLine) twonor
//nor_256_43 (out_256 vdd norout256_43 vdd vss PBulkLine NBulkLine) twonor
//nor_256_44 (out_256 vdd norout256_44 vdd vss PBulkLine NBulkLine) twonor
//nor_256_45 (out_256 vdd norout256_45 vdd vss PBulkLine NBulkLine) twonor
//nor_256_46 (out_256 vdd norout256_46 vdd vss PBulkLine NBulkLine) twonor
//nor_256_47 (out_256 vdd norout256_47 vdd vss PBulkLine NBulkLine) twonor
//nor_256_48 (out_256 vdd norout256_48 vdd vss PBulkLine NBulkLine) twonor
//nor_256_49 (out_256 vdd norout256_49 vdd vss PBulkLine NBulkLine) twonor
//nor_256_50 (out_256 vdd norout256_50 vdd vss PBulkLine NBulkLine) twonor
//nor_256_51 (out_256 vdd norout256_51 vdd vss PBulkLine NBulkLine) twonor
//nor_256_52 (out_256 vdd norout256_52 vdd vss PBulkLine NBulkLine) twonor
//nor_256_53 (out_256 vdd norout256_53 vdd vss PBulkLine NBulkLine) twonor
//nor_256_54 (out_256 vdd norout256_54 vdd vss PBulkLine NBulkLine) twonor
//nor_256_55 (out_256 vdd norout256_55 vdd vss PBulkLine NBulkLine) twonor
//nor_256_56 (out_256 vdd norout256_56 vdd vss PBulkLine NBulkLine) twonor
//nor_256_57 (out_256 vdd norout256_57 vdd vss PBulkLine NBulkLine) twonor
//nor_256_58 (out_256 vdd norout256_58 vdd vss PBulkLine NBulkLine) twonor
//nor_256_59 (out_256 vdd norout256_59 vdd vss PBulkLine NBulkLine) twonor
//nor_256_60 (out_256 vdd norout256_60 vdd vss PBulkLine NBulkLine) twonor
//nor_256_61 (out_256 vdd norout256_61 vdd vss PBulkLine NBulkLine) twonor
//nor_256_62 (out_256 vdd norout256_62 vdd vss PBulkLine NBulkLine) twonor
//nor_256_63 (out_256 vdd norout256_63 vdd vss PBulkLine NBulkLine) twonor
//nor_256_64 (out_256 vdd norout256_64 vdd vss PBulkLine NBulkLine) twonor
//nor_256_65 (out_256 vdd norout256_65 vdd vss PBulkLine NBulkLine) twonor
//nor_256_66 (out_256 vdd norout256_66 vdd vss PBulkLine NBulkLine) twonor
//nor_256_67 (out_256 vdd norout256_67 vdd vss PBulkLine NBulkLine) twonor
//nor_256_68 (out_256 vdd norout256_68 vdd vss PBulkLine NBulkLine) twonor
//nor_256_69 (out_256 vdd norout256_69 vdd vss PBulkLine NBulkLine) twonor
//nor_256_70 (out_256 vdd norout256_70 vdd vss PBulkLine NBulkLine) twonor
//nor_256_71 (out_256 vdd norout256_71 vdd vss PBulkLine NBulkLine) twonor
//nor_256_72 (out_256 vdd norout256_72 vdd vss PBulkLine NBulkLine) twonor
//nor_256_73 (out_256 vdd norout256_73 vdd vss PBulkLine NBulkLine) twonor
//nor_256_74 (out_256 vdd norout256_74 vdd vss PBulkLine NBulkLine) twonor
//nor_256_75 (out_256 vdd norout256_75 vdd vss PBulkLine NBulkLine) twonor
//nor_256_76 (out_256 vdd norout256_76 vdd vss PBulkLine NBulkLine) twonor
//nor_256_77 (out_256 vdd norout256_77 vdd vss PBulkLine NBulkLine) twonor
//nor_256_78 (out_256 vdd norout256_78 vdd vss PBulkLine NBulkLine) twonor
//nor_256_79 (out_256 vdd norout256_79 vdd vss PBulkLine NBulkLine) twonor
//nor_256_80 (out_256 vdd norout256_80 vdd vss PBulkLine NBulkLine) twonor
//nor_256_81 (out_256 vdd norout256_81 vdd vss PBulkLine NBulkLine) twonor
//nor_256_82 (out_256 vdd norout256_82 vdd vss PBulkLine NBulkLine) twonor
//nor_256_83 (out_256 vdd norout256_83 vdd vss PBulkLine NBulkLine) twonor
//nor_256_84 (out_256 vdd norout256_84 vdd vss PBulkLine NBulkLine) twonor
//nor_256_85 (out_256 vdd norout256_85 vdd vss PBulkLine NBulkLine) twonor
//nor_256_86 (out_256 vdd norout256_86 vdd vss PBulkLine NBulkLine) twonor
//nor_256_87 (out_256 vdd norout256_87 vdd vss PBulkLine NBulkLine) twonor
//nor_256_88 (out_256 vdd norout256_88 vdd vss PBulkLine NBulkLine) twonor
//nor_256_89 (out_256 vdd norout256_89 vdd vss PBulkLine NBulkLine) twonor
//nor_256_90 (out_256 vdd norout256_90 vdd vss PBulkLine NBulkLine) twonor
//nor_256_91 (out_256 vdd norout256_91 vdd vss PBulkLine NBulkLine) twonor
//nor_256_92 (out_256 vdd norout256_92 vdd vss PBulkLine NBulkLine) twonor
//nor_256_93 (out_256 vdd norout256_93 vdd vss PBulkLine NBulkLine) twonor
//nor_256_94 (out_256 vdd norout256_94 vdd vss PBulkLine NBulkLine) twonor
//nor_256_95 (out_256 vdd norout256_95 vdd vss PBulkLine NBulkLine) twonor
//nor_256_96 (out_256 vdd norout256_96 vdd vss PBulkLine NBulkLine) twonor
//nor_256_97 (out_256 vdd norout256_97 vdd vss PBulkLine NBulkLine) twonor
//nor_256_98 (out_256 vdd norout256_98 vdd vss PBulkLine NBulkLine) twonor
//nor_256_99 (out_256 vdd norout256_99 vdd vss PBulkLine NBulkLine) twonor
//nor_256_100 (out_256 vdd norout256_100 vdd vss PBulkLine NBulkLine) twonor
//nor_256_101 (out_256 vdd norout256_101 vdd vss PBulkLine NBulkLine) twonor
//nor_256_102 (out_256 vdd norout256_102 vdd vss PBulkLine NBulkLine) twonor
//nor_256_103 (out_256 vdd norout256_103 vdd vss PBulkLine NBulkLine) twonor
//nor_256_104 (out_256 vdd norout256_104 vdd vss PBulkLine NBulkLine) twonor
//nor_256_105 (out_256 vdd norout256_105 vdd vss PBulkLine NBulkLine) twonor
//nor_256_106 (out_256 vdd norout256_106 vdd vss PBulkLine NBulkLine) twonor
//nor_256_107 (out_256 vdd norout256_107 vdd vss PBulkLine NBulkLine) twonor
//nor_256_108 (out_256 vdd norout256_108 vdd vss PBulkLine NBulkLine) twonor
//nor_256_109 (out_256 vdd norout256_109 vdd vss PBulkLine NBulkLine) twonor
//nor_256_110 (out_256 vdd norout256_110 vdd vss PBulkLine NBulkLine) twonor
//nor_256_111 (out_256 vdd norout256_111 vdd vss PBulkLine NBulkLine) twonor
//nor_256_112 (out_256 vdd norout256_112 vdd vss PBulkLine NBulkLine) twonor
//nor_256_113 (out_256 vdd norout256_113 vdd vss PBulkLine NBulkLine) twonor
//nor_256_114 (out_256 vdd norout256_114 vdd vss PBulkLine NBulkLine) twonor
//nor_256_115 (out_256 vdd norout256_115 vdd vss PBulkLine NBulkLine) twonor
//nor_256_116 (out_256 vdd norout256_116 vdd vss PBulkLine NBulkLine) twonor
//nor_256_117 (out_256 vdd norout256_117 vdd vss PBulkLine NBulkLine) twonor
//nor_256_118 (out_256 vdd norout256_118 vdd vss PBulkLine NBulkLine) twonor
//nor_256_119 (out_256 vdd norout256_119 vdd vss PBulkLine NBulkLine) twonor
//nor_256_120 (out_256 vdd norout256_120 vdd vss PBulkLine NBulkLine) twonor
//nor_256_121 (out_256 vdd norout256_121 vdd vss PBulkLine NBulkLine) twonor
//nor_256_122 (out_256 vdd norout256_122 vdd vss PBulkLine NBulkLine) twonor
//nor_256_123 (out_256 vdd norout256_123 vdd vss PBulkLine NBulkLine) twonor
//nor_256_124 (out_256 vdd norout256_124 vdd vss PBulkLine NBulkLine) twonor
//nor_256_125 (out_256 vdd norout256_125 vdd vss PBulkLine NBulkLine) twonor
//nor_256_126 (out_256 vdd norout256_126 vdd vss PBulkLine NBulkLine) twonor
//nor_256_127 (out_256 vdd norout256_127 vdd vss PBulkLine NBulkLine) twonor
//nor_256_128 (out_256 vdd norout256_128 vdd vss PBulkLine NBulkLine) twonor
//nor_256_129 (out_256 vdd norout256_129 vdd vss PBulkLine NBulkLine) twonor
//nor_256_130 (out_256 vdd norout256_130 vdd vss PBulkLine NBulkLine) twonor
//nor_256_131 (out_256 vdd norout256_131 vdd vss PBulkLine NBulkLine) twonor
//nor_256_132 (out_256 vdd norout256_132 vdd vss PBulkLine NBulkLine) twonor
//nor_256_133 (out_256 vdd norout256_133 vdd vss PBulkLine NBulkLine) twonor
//nor_256_134 (out_256 vdd norout256_134 vdd vss PBulkLine NBulkLine) twonor
//nor_256_135 (out_256 vdd norout256_135 vdd vss PBulkLine NBulkLine) twonor
//nor_256_136 (out_256 vdd norout256_136 vdd vss PBulkLine NBulkLine) twonor
//nor_256_137 (out_256 vdd norout256_137 vdd vss PBulkLine NBulkLine) twonor
//nor_256_138 (out_256 vdd norout256_138 vdd vss PBulkLine NBulkLine) twonor
//nor_256_139 (out_256 vdd norout256_139 vdd vss PBulkLine NBulkLine) twonor
//nor_256_140 (out_256 vdd norout256_140 vdd vss PBulkLine NBulkLine) twonor
//nor_256_141 (out_256 vdd norout256_141 vdd vss PBulkLine NBulkLine) twonor
//nor_256_142 (out_256 vdd norout256_142 vdd vss PBulkLine NBulkLine) twonor
//nor_256_143 (out_256 vdd norout256_143 vdd vss PBulkLine NBulkLine) twonor
//nor_256_144 (out_256 vdd norout256_144 vdd vss PBulkLine NBulkLine) twonor
//nor_256_145 (out_256 vdd norout256_145 vdd vss PBulkLine NBulkLine) twonor
//nor_256_146 (out_256 vdd norout256_146 vdd vss PBulkLine NBulkLine) twonor
//nor_256_147 (out_256 vdd norout256_147 vdd vss PBulkLine NBulkLine) twonor
//nor_256_148 (out_256 vdd norout256_148 vdd vss PBulkLine NBulkLine) twonor
//nor_256_149 (out_256 vdd norout256_149 vdd vss PBulkLine NBulkLine) twonor
//nor_256_150 (out_256 vdd norout256_150 vdd vss PBulkLine NBulkLine) twonor
//nor_256_151 (out_256 vdd norout256_151 vdd vss PBulkLine NBulkLine) twonor
//nor_256_152 (out_256 vdd norout256_152 vdd vss PBulkLine NBulkLine) twonor
//nor_256_153 (out_256 vdd norout256_153 vdd vss PBulkLine NBulkLine) twonor
//nor_256_154 (out_256 vdd norout256_154 vdd vss PBulkLine NBulkLine) twonor
//nor_256_155 (out_256 vdd norout256_155 vdd vss PBulkLine NBulkLine) twonor
//nor_256_156 (out_256 vdd norout256_156 vdd vss PBulkLine NBulkLine) twonor
//nor_256_157 (out_256 vdd norout256_157 vdd vss PBulkLine NBulkLine) twonor
//nor_256_158 (out_256 vdd norout256_158 vdd vss PBulkLine NBulkLine) twonor
//nor_256_159 (out_256 vdd norout256_159 vdd vss PBulkLine NBulkLine) twonor
//nor_256_160 (out_256 vdd norout256_160 vdd vss PBulkLine NBulkLine) twonor
//nor_256_161 (out_256 vdd norout256_161 vdd vss PBulkLine NBulkLine) twonor
//nor_256_162 (out_256 vdd norout256_162 vdd vss PBulkLine NBulkLine) twonor
//nor_256_163 (out_256 vdd norout256_163 vdd vss PBulkLine NBulkLine) twonor
//nor_256_164 (out_256 vdd norout256_164 vdd vss PBulkLine NBulkLine) twonor
//nor_256_165 (out_256 vdd norout256_165 vdd vss PBulkLine NBulkLine) twonor
//nor_256_166 (out_256 vdd norout256_166 vdd vss PBulkLine NBulkLine) twonor
//nor_256_167 (out_256 vdd norout256_167 vdd vss PBulkLine NBulkLine) twonor
//nor_256_168 (out_256 vdd norout256_168 vdd vss PBulkLine NBulkLine) twonor
//nor_256_169 (out_256 vdd norout256_169 vdd vss PBulkLine NBulkLine) twonor
//nor_256_170 (out_256 vdd norout256_170 vdd vss PBulkLine NBulkLine) twonor
//nor_256_171 (out_256 vdd norout256_171 vdd vss PBulkLine NBulkLine) twonor
//nor_256_172 (out_256 vdd norout256_172 vdd vss PBulkLine NBulkLine) twonor
//nor_256_173 (out_256 vdd norout256_173 vdd vss PBulkLine NBulkLine) twonor
//nor_256_174 (out_256 vdd norout256_174 vdd vss PBulkLine NBulkLine) twonor
//nor_256_175 (out_256 vdd norout256_175 vdd vss PBulkLine NBulkLine) twonor
//nor_256_176 (out_256 vdd norout256_176 vdd vss PBulkLine NBulkLine) twonor
//nor_256_177 (out_256 vdd norout256_177 vdd vss PBulkLine NBulkLine) twonor
//nor_256_178 (out_256 vdd norout256_178 vdd vss PBulkLine NBulkLine) twonor
//nor_256_179 (out_256 vdd norout256_179 vdd vss PBulkLine NBulkLine) twonor
//nor_256_180 (out_256 vdd norout256_180 vdd vss PBulkLine NBulkLine) twonor
//nor_256_181 (out_256 vdd norout256_181 vdd vss PBulkLine NBulkLine) twonor
//nor_256_182 (out_256 vdd norout256_182 vdd vss PBulkLine NBulkLine) twonor
//nor_256_183 (out_256 vdd norout256_183 vdd vss PBulkLine NBulkLine) twonor
//nor_256_184 (out_256 vdd norout256_184 vdd vss PBulkLine NBulkLine) twonor
//nor_256_185 (out_256 vdd norout256_185 vdd vss PBulkLine NBulkLine) twonor
//nor_256_186 (out_256 vdd norout256_186 vdd vss PBulkLine NBulkLine) twonor
//nor_256_187 (out_256 vdd norout256_187 vdd vss PBulkLine NBulkLine) twonor
//nor_256_188 (out_256 vdd norout256_188 vdd vss PBulkLine NBulkLine) twonor
//nor_256_189 (out_256 vdd norout256_189 vdd vss PBulkLine NBulkLine) twonor
//nor_256_190 (out_256 vdd norout256_190 vdd vss PBulkLine NBulkLine) twonor
//nor_256_191 (out_256 vdd norout256_191 vdd vss PBulkLine NBulkLine) twonor
//nor_256_192 (out_256 vdd norout256_192 vdd vss PBulkLine NBulkLine) twonor
//nor_256_193 (out_256 vdd norout256_193 vdd vss PBulkLine NBulkLine) twonor
//nor_256_194 (out_256 vdd norout256_194 vdd vss PBulkLine NBulkLine) twonor
//nor_256_195 (out_256 vdd norout256_195 vdd vss PBulkLine NBulkLine) twonor
//nor_256_196 (out_256 vdd norout256_196 vdd vss PBulkLine NBulkLine) twonor
//nor_256_197 (out_256 vdd norout256_197 vdd vss PBulkLine NBulkLine) twonor
//nor_256_198 (out_256 vdd norout256_198 vdd vss PBulkLine NBulkLine) twonor
//nor_256_199 (out_256 vdd norout256_199 vdd vss PBulkLine NBulkLine) twonor
//nor_256_200 (out_256 vdd norout256_200 vdd vss PBulkLine NBulkLine) twonor
//nor_256_201 (out_256 vdd norout256_201 vdd vss PBulkLine NBulkLine) twonor
//nor_256_202 (out_256 vdd norout256_202 vdd vss PBulkLine NBulkLine) twonor
//nor_256_203 (out_256 vdd norout256_203 vdd vss PBulkLine NBulkLine) twonor
//nor_256_204 (out_256 vdd norout256_204 vdd vss PBulkLine NBulkLine) twonor
//nor_256_205 (out_256 vdd norout256_205 vdd vss PBulkLine NBulkLine) twonor
//nor_256_206 (out_256 vdd norout256_206 vdd vss PBulkLine NBulkLine) twonor
//nor_256_207 (out_256 vdd norout256_207 vdd vss PBulkLine NBulkLine) twonor
//nor_256_208 (out_256 vdd norout256_208 vdd vss PBulkLine NBulkLine) twonor
//nor_256_209 (out_256 vdd norout256_209 vdd vss PBulkLine NBulkLine) twonor
//nor_256_210 (out_256 vdd norout256_210 vdd vss PBulkLine NBulkLine) twonor
//nor_256_211 (out_256 vdd norout256_211 vdd vss PBulkLine NBulkLine) twonor
//nor_256_212 (out_256 vdd norout256_212 vdd vss PBulkLine NBulkLine) twonor
//nor_256_213 (out_256 vdd norout256_213 vdd vss PBulkLine NBulkLine) twonor
//nor_256_214 (out_256 vdd norout256_214 vdd vss PBulkLine NBulkLine) twonor
//nor_256_215 (out_256 vdd norout256_215 vdd vss PBulkLine NBulkLine) twonor
//nor_256_216 (out_256 vdd norout256_216 vdd vss PBulkLine NBulkLine) twonor
//nor_256_217 (out_256 vdd norout256_217 vdd vss PBulkLine NBulkLine) twonor
//nor_256_218 (out_256 vdd norout256_218 vdd vss PBulkLine NBulkLine) twonor
//nor_256_219 (out_256 vdd norout256_219 vdd vss PBulkLine NBulkLine) twonor
//nor_256_220 (out_256 vdd norout256_220 vdd vss PBulkLine NBulkLine) twonor
//nor_256_221 (out_256 vdd norout256_221 vdd vss PBulkLine NBulkLine) twonor
//nor_256_222 (out_256 vdd norout256_222 vdd vss PBulkLine NBulkLine) twonor
//nor_256_223 (out_256 vdd norout256_223 vdd vss PBulkLine NBulkLine) twonor
//nor_256_224 (out_256 vdd norout256_224 vdd vss PBulkLine NBulkLine) twonor
//nor_256_225 (out_256 vdd norout256_225 vdd vss PBulkLine NBulkLine) twonor
//nor_256_226 (out_256 vdd norout256_226 vdd vss PBulkLine NBulkLine) twonor
//nor_256_227 (out_256 vdd norout256_227 vdd vss PBulkLine NBulkLine) twonor
//nor_256_228 (out_256 vdd norout256_228 vdd vss PBulkLine NBulkLine) twonor
//nor_256_229 (out_256 vdd norout256_229 vdd vss PBulkLine NBulkLine) twonor
//nor_256_230 (out_256 vdd norout256_230 vdd vss PBulkLine NBulkLine) twonor
//nor_256_231 (out_256 vdd norout256_231 vdd vss PBulkLine NBulkLine) twonor
//nor_256_232 (out_256 vdd norout256_232 vdd vss PBulkLine NBulkLine) twonor
//nor_256_233 (out_256 vdd norout256_233 vdd vss PBulkLine NBulkLine) twonor
//nor_256_234 (out_256 vdd norout256_234 vdd vss PBulkLine NBulkLine) twonor
//nor_256_235 (out_256 vdd norout256_235 vdd vss PBulkLine NBulkLine) twonor
//nor_256_236 (out_256 vdd norout256_236 vdd vss PBulkLine NBulkLine) twonor
//nor_256_237 (out_256 vdd norout256_237 vdd vss PBulkLine NBulkLine) twonor
//nor_256_238 (out_256 vdd norout256_238 vdd vss PBulkLine NBulkLine) twonor
//nor_256_239 (out_256 vdd norout256_239 vdd vss PBulkLine NBulkLine) twonor
//nor_256_240 (out_256 vdd norout256_240 vdd vss PBulkLine NBulkLine) twonor
//nor_256_241 (out_256 vdd norout256_241 vdd vss PBulkLine NBulkLine) twonor
//nor_256_242 (out_256 vdd norout256_242 vdd vss PBulkLine NBulkLine) twonor
//nor_256_243 (out_256 vdd norout256_243 vdd vss PBulkLine NBulkLine) twonor
//nor_256_244 (out_256 vdd norout256_244 vdd vss PBulkLine NBulkLine) twonor
//nor_256_245 (out_256 vdd norout256_245 vdd vss PBulkLine NBulkLine) twonor
//nor_256_246 (out_256 vdd norout256_246 vdd vss PBulkLine NBulkLine) twonor
//nor_256_247 (out_256 vdd norout256_247 vdd vss PBulkLine NBulkLine) twonor
//nor_256_248 (out_256 vdd norout256_248 vdd vss PBulkLine NBulkLine) twonor
//nor_256_249 (out_256 vdd norout256_249 vdd vss PBulkLine NBulkLine) twonor
//nor_256_250 (out_256 vdd norout256_250 vdd vss PBulkLine NBulkLine) twonor
//nor_256_251 (out_256 vdd norout256_251 vdd vss PBulkLine NBulkLine) twonor
//nor_256_252 (out_256 vdd norout256_252 vdd vss PBulkLine NBulkLine) twonor
//nor_256_253 (out_256 vdd norout256_253 vdd vss PBulkLine NBulkLine) twonor
//nor_256_254 (out_256 vdd norout256_254 vdd vss PBulkLine NBulkLine) twonor
//nor_256_255 (out_256 vdd norout256_255 vdd vss PBulkLine NBulkLine) twonor
//nor_256_256 (out_256 vdd norout256_256 vdd vss PBulkLine NBulkLine) twonor
cPar_256 out_256 vss capacitor c=4.608e-14
xNot_512_a (in temp_512 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_512_b (temp_512 out_512 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_512_1 (out_512 vdd norout512_1 vdd vss PBulkLine NBulkLine) twonor
//nor_512_2 (out_512 vdd norout512_2 vdd vss PBulkLine NBulkLine) twonor
//nor_512_3 (out_512 vdd norout512_3 vdd vss PBulkLine NBulkLine) twonor
//nor_512_4 (out_512 vdd norout512_4 vdd vss PBulkLine NBulkLine) twonor
//nor_512_5 (out_512 vdd norout512_5 vdd vss PBulkLine NBulkLine) twonor
//nor_512_6 (out_512 vdd norout512_6 vdd vss PBulkLine NBulkLine) twonor
//nor_512_7 (out_512 vdd norout512_7 vdd vss PBulkLine NBulkLine) twonor
//nor_512_8 (out_512 vdd norout512_8 vdd vss PBulkLine NBulkLine) twonor
//nor_512_9 (out_512 vdd norout512_9 vdd vss PBulkLine NBulkLine) twonor
//nor_512_10 (out_512 vdd norout512_10 vdd vss PBulkLine NBulkLine) twonor
//nor_512_11 (out_512 vdd norout512_11 vdd vss PBulkLine NBulkLine) twonor
//nor_512_12 (out_512 vdd norout512_12 vdd vss PBulkLine NBulkLine) twonor
//nor_512_13 (out_512 vdd norout512_13 vdd vss PBulkLine NBulkLine) twonor
//nor_512_14 (out_512 vdd norout512_14 vdd vss PBulkLine NBulkLine) twonor
//nor_512_15 (out_512 vdd norout512_15 vdd vss PBulkLine NBulkLine) twonor
//nor_512_16 (out_512 vdd norout512_16 vdd vss PBulkLine NBulkLine) twonor
//nor_512_17 (out_512 vdd norout512_17 vdd vss PBulkLine NBulkLine) twonor
//nor_512_18 (out_512 vdd norout512_18 vdd vss PBulkLine NBulkLine) twonor
//nor_512_19 (out_512 vdd norout512_19 vdd vss PBulkLine NBulkLine) twonor
//nor_512_20 (out_512 vdd norout512_20 vdd vss PBulkLine NBulkLine) twonor
//nor_512_21 (out_512 vdd norout512_21 vdd vss PBulkLine NBulkLine) twonor
//nor_512_22 (out_512 vdd norout512_22 vdd vss PBulkLine NBulkLine) twonor
//nor_512_23 (out_512 vdd norout512_23 vdd vss PBulkLine NBulkLine) twonor
//nor_512_24 (out_512 vdd norout512_24 vdd vss PBulkLine NBulkLine) twonor
//nor_512_25 (out_512 vdd norout512_25 vdd vss PBulkLine NBulkLine) twonor
//nor_512_26 (out_512 vdd norout512_26 vdd vss PBulkLine NBulkLine) twonor
//nor_512_27 (out_512 vdd norout512_27 vdd vss PBulkLine NBulkLine) twonor
//nor_512_28 (out_512 vdd norout512_28 vdd vss PBulkLine NBulkLine) twonor
//nor_512_29 (out_512 vdd norout512_29 vdd vss PBulkLine NBulkLine) twonor
//nor_512_30 (out_512 vdd norout512_30 vdd vss PBulkLine NBulkLine) twonor
//nor_512_31 (out_512 vdd norout512_31 vdd vss PBulkLine NBulkLine) twonor
//nor_512_32 (out_512 vdd norout512_32 vdd vss PBulkLine NBulkLine) twonor
//nor_512_33 (out_512 vdd norout512_33 vdd vss PBulkLine NBulkLine) twonor
//nor_512_34 (out_512 vdd norout512_34 vdd vss PBulkLine NBulkLine) twonor
//nor_512_35 (out_512 vdd norout512_35 vdd vss PBulkLine NBulkLine) twonor
//nor_512_36 (out_512 vdd norout512_36 vdd vss PBulkLine NBulkLine) twonor
//nor_512_37 (out_512 vdd norout512_37 vdd vss PBulkLine NBulkLine) twonor
//nor_512_38 (out_512 vdd norout512_38 vdd vss PBulkLine NBulkLine) twonor
//nor_512_39 (out_512 vdd norout512_39 vdd vss PBulkLine NBulkLine) twonor
//nor_512_40 (out_512 vdd norout512_40 vdd vss PBulkLine NBulkLine) twonor
//nor_512_41 (out_512 vdd norout512_41 vdd vss PBulkLine NBulkLine) twonor
//nor_512_42 (out_512 vdd norout512_42 vdd vss PBulkLine NBulkLine) twonor
//nor_512_43 (out_512 vdd norout512_43 vdd vss PBulkLine NBulkLine) twonor
//nor_512_44 (out_512 vdd norout512_44 vdd vss PBulkLine NBulkLine) twonor
//nor_512_45 (out_512 vdd norout512_45 vdd vss PBulkLine NBulkLine) twonor
//nor_512_46 (out_512 vdd norout512_46 vdd vss PBulkLine NBulkLine) twonor
//nor_512_47 (out_512 vdd norout512_47 vdd vss PBulkLine NBulkLine) twonor
//nor_512_48 (out_512 vdd norout512_48 vdd vss PBulkLine NBulkLine) twonor
//nor_512_49 (out_512 vdd norout512_49 vdd vss PBulkLine NBulkLine) twonor
//nor_512_50 (out_512 vdd norout512_50 vdd vss PBulkLine NBulkLine) twonor
//nor_512_51 (out_512 vdd norout512_51 vdd vss PBulkLine NBulkLine) twonor
//nor_512_52 (out_512 vdd norout512_52 vdd vss PBulkLine NBulkLine) twonor
//nor_512_53 (out_512 vdd norout512_53 vdd vss PBulkLine NBulkLine) twonor
//nor_512_54 (out_512 vdd norout512_54 vdd vss PBulkLine NBulkLine) twonor
//nor_512_55 (out_512 vdd norout512_55 vdd vss PBulkLine NBulkLine) twonor
//nor_512_56 (out_512 vdd norout512_56 vdd vss PBulkLine NBulkLine) twonor
//nor_512_57 (out_512 vdd norout512_57 vdd vss PBulkLine NBulkLine) twonor
//nor_512_58 (out_512 vdd norout512_58 vdd vss PBulkLine NBulkLine) twonor
//nor_512_59 (out_512 vdd norout512_59 vdd vss PBulkLine NBulkLine) twonor
//nor_512_60 (out_512 vdd norout512_60 vdd vss PBulkLine NBulkLine) twonor
//nor_512_61 (out_512 vdd norout512_61 vdd vss PBulkLine NBulkLine) twonor
//nor_512_62 (out_512 vdd norout512_62 vdd vss PBulkLine NBulkLine) twonor
//nor_512_63 (out_512 vdd norout512_63 vdd vss PBulkLine NBulkLine) twonor
//nor_512_64 (out_512 vdd norout512_64 vdd vss PBulkLine NBulkLine) twonor
//nor_512_65 (out_512 vdd norout512_65 vdd vss PBulkLine NBulkLine) twonor
//nor_512_66 (out_512 vdd norout512_66 vdd vss PBulkLine NBulkLine) twonor
//nor_512_67 (out_512 vdd norout512_67 vdd vss PBulkLine NBulkLine) twonor
//nor_512_68 (out_512 vdd norout512_68 vdd vss PBulkLine NBulkLine) twonor
//nor_512_69 (out_512 vdd norout512_69 vdd vss PBulkLine NBulkLine) twonor
//nor_512_70 (out_512 vdd norout512_70 vdd vss PBulkLine NBulkLine) twonor
//nor_512_71 (out_512 vdd norout512_71 vdd vss PBulkLine NBulkLine) twonor
//nor_512_72 (out_512 vdd norout512_72 vdd vss PBulkLine NBulkLine) twonor
//nor_512_73 (out_512 vdd norout512_73 vdd vss PBulkLine NBulkLine) twonor
//nor_512_74 (out_512 vdd norout512_74 vdd vss PBulkLine NBulkLine) twonor
//nor_512_75 (out_512 vdd norout512_75 vdd vss PBulkLine NBulkLine) twonor
//nor_512_76 (out_512 vdd norout512_76 vdd vss PBulkLine NBulkLine) twonor
//nor_512_77 (out_512 vdd norout512_77 vdd vss PBulkLine NBulkLine) twonor
//nor_512_78 (out_512 vdd norout512_78 vdd vss PBulkLine NBulkLine) twonor
//nor_512_79 (out_512 vdd norout512_79 vdd vss PBulkLine NBulkLine) twonor
//nor_512_80 (out_512 vdd norout512_80 vdd vss PBulkLine NBulkLine) twonor
//nor_512_81 (out_512 vdd norout512_81 vdd vss PBulkLine NBulkLine) twonor
//nor_512_82 (out_512 vdd norout512_82 vdd vss PBulkLine NBulkLine) twonor
//nor_512_83 (out_512 vdd norout512_83 vdd vss PBulkLine NBulkLine) twonor
//nor_512_84 (out_512 vdd norout512_84 vdd vss PBulkLine NBulkLine) twonor
//nor_512_85 (out_512 vdd norout512_85 vdd vss PBulkLine NBulkLine) twonor
//nor_512_86 (out_512 vdd norout512_86 vdd vss PBulkLine NBulkLine) twonor
//nor_512_87 (out_512 vdd norout512_87 vdd vss PBulkLine NBulkLine) twonor
//nor_512_88 (out_512 vdd norout512_88 vdd vss PBulkLine NBulkLine) twonor
//nor_512_89 (out_512 vdd norout512_89 vdd vss PBulkLine NBulkLine) twonor
//nor_512_90 (out_512 vdd norout512_90 vdd vss PBulkLine NBulkLine) twonor
//nor_512_91 (out_512 vdd norout512_91 vdd vss PBulkLine NBulkLine) twonor
//nor_512_92 (out_512 vdd norout512_92 vdd vss PBulkLine NBulkLine) twonor
//nor_512_93 (out_512 vdd norout512_93 vdd vss PBulkLine NBulkLine) twonor
//nor_512_94 (out_512 vdd norout512_94 vdd vss PBulkLine NBulkLine) twonor
//nor_512_95 (out_512 vdd norout512_95 vdd vss PBulkLine NBulkLine) twonor
//nor_512_96 (out_512 vdd norout512_96 vdd vss PBulkLine NBulkLine) twonor
//nor_512_97 (out_512 vdd norout512_97 vdd vss PBulkLine NBulkLine) twonor
//nor_512_98 (out_512 vdd norout512_98 vdd vss PBulkLine NBulkLine) twonor
//nor_512_99 (out_512 vdd norout512_99 vdd vss PBulkLine NBulkLine) twonor
//nor_512_100 (out_512 vdd norout512_100 vdd vss PBulkLine NBulkLine) twonor
//nor_512_101 (out_512 vdd norout512_101 vdd vss PBulkLine NBulkLine) twonor
//nor_512_102 (out_512 vdd norout512_102 vdd vss PBulkLine NBulkLine) twonor
//nor_512_103 (out_512 vdd norout512_103 vdd vss PBulkLine NBulkLine) twonor
//nor_512_104 (out_512 vdd norout512_104 vdd vss PBulkLine NBulkLine) twonor
//nor_512_105 (out_512 vdd norout512_105 vdd vss PBulkLine NBulkLine) twonor
//nor_512_106 (out_512 vdd norout512_106 vdd vss PBulkLine NBulkLine) twonor
//nor_512_107 (out_512 vdd norout512_107 vdd vss PBulkLine NBulkLine) twonor
//nor_512_108 (out_512 vdd norout512_108 vdd vss PBulkLine NBulkLine) twonor
//nor_512_109 (out_512 vdd norout512_109 vdd vss PBulkLine NBulkLine) twonor
//nor_512_110 (out_512 vdd norout512_110 vdd vss PBulkLine NBulkLine) twonor
//nor_512_111 (out_512 vdd norout512_111 vdd vss PBulkLine NBulkLine) twonor
//nor_512_112 (out_512 vdd norout512_112 vdd vss PBulkLine NBulkLine) twonor
//nor_512_113 (out_512 vdd norout512_113 vdd vss PBulkLine NBulkLine) twonor
//nor_512_114 (out_512 vdd norout512_114 vdd vss PBulkLine NBulkLine) twonor
//nor_512_115 (out_512 vdd norout512_115 vdd vss PBulkLine NBulkLine) twonor
//nor_512_116 (out_512 vdd norout512_116 vdd vss PBulkLine NBulkLine) twonor
//nor_512_117 (out_512 vdd norout512_117 vdd vss PBulkLine NBulkLine) twonor
//nor_512_118 (out_512 vdd norout512_118 vdd vss PBulkLine NBulkLine) twonor
//nor_512_119 (out_512 vdd norout512_119 vdd vss PBulkLine NBulkLine) twonor
//nor_512_120 (out_512 vdd norout512_120 vdd vss PBulkLine NBulkLine) twonor
//nor_512_121 (out_512 vdd norout512_121 vdd vss PBulkLine NBulkLine) twonor
//nor_512_122 (out_512 vdd norout512_122 vdd vss PBulkLine NBulkLine) twonor
//nor_512_123 (out_512 vdd norout512_123 vdd vss PBulkLine NBulkLine) twonor
//nor_512_124 (out_512 vdd norout512_124 vdd vss PBulkLine NBulkLine) twonor
//nor_512_125 (out_512 vdd norout512_125 vdd vss PBulkLine NBulkLine) twonor
//nor_512_126 (out_512 vdd norout512_126 vdd vss PBulkLine NBulkLine) twonor
//nor_512_127 (out_512 vdd norout512_127 vdd vss PBulkLine NBulkLine) twonor
//nor_512_128 (out_512 vdd norout512_128 vdd vss PBulkLine NBulkLine) twonor
//nor_512_129 (out_512 vdd norout512_129 vdd vss PBulkLine NBulkLine) twonor
//nor_512_130 (out_512 vdd norout512_130 vdd vss PBulkLine NBulkLine) twonor
//nor_512_131 (out_512 vdd norout512_131 vdd vss PBulkLine NBulkLine) twonor
//nor_512_132 (out_512 vdd norout512_132 vdd vss PBulkLine NBulkLine) twonor
//nor_512_133 (out_512 vdd norout512_133 vdd vss PBulkLine NBulkLine) twonor
//nor_512_134 (out_512 vdd norout512_134 vdd vss PBulkLine NBulkLine) twonor
//nor_512_135 (out_512 vdd norout512_135 vdd vss PBulkLine NBulkLine) twonor
//nor_512_136 (out_512 vdd norout512_136 vdd vss PBulkLine NBulkLine) twonor
//nor_512_137 (out_512 vdd norout512_137 vdd vss PBulkLine NBulkLine) twonor
//nor_512_138 (out_512 vdd norout512_138 vdd vss PBulkLine NBulkLine) twonor
//nor_512_139 (out_512 vdd norout512_139 vdd vss PBulkLine NBulkLine) twonor
//nor_512_140 (out_512 vdd norout512_140 vdd vss PBulkLine NBulkLine) twonor
//nor_512_141 (out_512 vdd norout512_141 vdd vss PBulkLine NBulkLine) twonor
//nor_512_142 (out_512 vdd norout512_142 vdd vss PBulkLine NBulkLine) twonor
//nor_512_143 (out_512 vdd norout512_143 vdd vss PBulkLine NBulkLine) twonor
//nor_512_144 (out_512 vdd norout512_144 vdd vss PBulkLine NBulkLine) twonor
//nor_512_145 (out_512 vdd norout512_145 vdd vss PBulkLine NBulkLine) twonor
//nor_512_146 (out_512 vdd norout512_146 vdd vss PBulkLine NBulkLine) twonor
//nor_512_147 (out_512 vdd norout512_147 vdd vss PBulkLine NBulkLine) twonor
//nor_512_148 (out_512 vdd norout512_148 vdd vss PBulkLine NBulkLine) twonor
//nor_512_149 (out_512 vdd norout512_149 vdd vss PBulkLine NBulkLine) twonor
//nor_512_150 (out_512 vdd norout512_150 vdd vss PBulkLine NBulkLine) twonor
//nor_512_151 (out_512 vdd norout512_151 vdd vss PBulkLine NBulkLine) twonor
//nor_512_152 (out_512 vdd norout512_152 vdd vss PBulkLine NBulkLine) twonor
//nor_512_153 (out_512 vdd norout512_153 vdd vss PBulkLine NBulkLine) twonor
//nor_512_154 (out_512 vdd norout512_154 vdd vss PBulkLine NBulkLine) twonor
//nor_512_155 (out_512 vdd norout512_155 vdd vss PBulkLine NBulkLine) twonor
//nor_512_156 (out_512 vdd norout512_156 vdd vss PBulkLine NBulkLine) twonor
//nor_512_157 (out_512 vdd norout512_157 vdd vss PBulkLine NBulkLine) twonor
//nor_512_158 (out_512 vdd norout512_158 vdd vss PBulkLine NBulkLine) twonor
//nor_512_159 (out_512 vdd norout512_159 vdd vss PBulkLine NBulkLine) twonor
//nor_512_160 (out_512 vdd norout512_160 vdd vss PBulkLine NBulkLine) twonor
//nor_512_161 (out_512 vdd norout512_161 vdd vss PBulkLine NBulkLine) twonor
//nor_512_162 (out_512 vdd norout512_162 vdd vss PBulkLine NBulkLine) twonor
//nor_512_163 (out_512 vdd norout512_163 vdd vss PBulkLine NBulkLine) twonor
//nor_512_164 (out_512 vdd norout512_164 vdd vss PBulkLine NBulkLine) twonor
//nor_512_165 (out_512 vdd norout512_165 vdd vss PBulkLine NBulkLine) twonor
//nor_512_166 (out_512 vdd norout512_166 vdd vss PBulkLine NBulkLine) twonor
//nor_512_167 (out_512 vdd norout512_167 vdd vss PBulkLine NBulkLine) twonor
//nor_512_168 (out_512 vdd norout512_168 vdd vss PBulkLine NBulkLine) twonor
//nor_512_169 (out_512 vdd norout512_169 vdd vss PBulkLine NBulkLine) twonor
//nor_512_170 (out_512 vdd norout512_170 vdd vss PBulkLine NBulkLine) twonor
//nor_512_171 (out_512 vdd norout512_171 vdd vss PBulkLine NBulkLine) twonor
//nor_512_172 (out_512 vdd norout512_172 vdd vss PBulkLine NBulkLine) twonor
//nor_512_173 (out_512 vdd norout512_173 vdd vss PBulkLine NBulkLine) twonor
//nor_512_174 (out_512 vdd norout512_174 vdd vss PBulkLine NBulkLine) twonor
//nor_512_175 (out_512 vdd norout512_175 vdd vss PBulkLine NBulkLine) twonor
//nor_512_176 (out_512 vdd norout512_176 vdd vss PBulkLine NBulkLine) twonor
//nor_512_177 (out_512 vdd norout512_177 vdd vss PBulkLine NBulkLine) twonor
//nor_512_178 (out_512 vdd norout512_178 vdd vss PBulkLine NBulkLine) twonor
//nor_512_179 (out_512 vdd norout512_179 vdd vss PBulkLine NBulkLine) twonor
//nor_512_180 (out_512 vdd norout512_180 vdd vss PBulkLine NBulkLine) twonor
//nor_512_181 (out_512 vdd norout512_181 vdd vss PBulkLine NBulkLine) twonor
//nor_512_182 (out_512 vdd norout512_182 vdd vss PBulkLine NBulkLine) twonor
//nor_512_183 (out_512 vdd norout512_183 vdd vss PBulkLine NBulkLine) twonor
//nor_512_184 (out_512 vdd norout512_184 vdd vss PBulkLine NBulkLine) twonor
//nor_512_185 (out_512 vdd norout512_185 vdd vss PBulkLine NBulkLine) twonor
//nor_512_186 (out_512 vdd norout512_186 vdd vss PBulkLine NBulkLine) twonor
//nor_512_187 (out_512 vdd norout512_187 vdd vss PBulkLine NBulkLine) twonor
//nor_512_188 (out_512 vdd norout512_188 vdd vss PBulkLine NBulkLine) twonor
//nor_512_189 (out_512 vdd norout512_189 vdd vss PBulkLine NBulkLine) twonor
//nor_512_190 (out_512 vdd norout512_190 vdd vss PBulkLine NBulkLine) twonor
//nor_512_191 (out_512 vdd norout512_191 vdd vss PBulkLine NBulkLine) twonor
//nor_512_192 (out_512 vdd norout512_192 vdd vss PBulkLine NBulkLine) twonor
//nor_512_193 (out_512 vdd norout512_193 vdd vss PBulkLine NBulkLine) twonor
//nor_512_194 (out_512 vdd norout512_194 vdd vss PBulkLine NBulkLine) twonor
//nor_512_195 (out_512 vdd norout512_195 vdd vss PBulkLine NBulkLine) twonor
//nor_512_196 (out_512 vdd norout512_196 vdd vss PBulkLine NBulkLine) twonor
//nor_512_197 (out_512 vdd norout512_197 vdd vss PBulkLine NBulkLine) twonor
//nor_512_198 (out_512 vdd norout512_198 vdd vss PBulkLine NBulkLine) twonor
//nor_512_199 (out_512 vdd norout512_199 vdd vss PBulkLine NBulkLine) twonor
//nor_512_200 (out_512 vdd norout512_200 vdd vss PBulkLine NBulkLine) twonor
//nor_512_201 (out_512 vdd norout512_201 vdd vss PBulkLine NBulkLine) twonor
//nor_512_202 (out_512 vdd norout512_202 vdd vss PBulkLine NBulkLine) twonor
//nor_512_203 (out_512 vdd norout512_203 vdd vss PBulkLine NBulkLine) twonor
//nor_512_204 (out_512 vdd norout512_204 vdd vss PBulkLine NBulkLine) twonor
//nor_512_205 (out_512 vdd norout512_205 vdd vss PBulkLine NBulkLine) twonor
//nor_512_206 (out_512 vdd norout512_206 vdd vss PBulkLine NBulkLine) twonor
//nor_512_207 (out_512 vdd norout512_207 vdd vss PBulkLine NBulkLine) twonor
//nor_512_208 (out_512 vdd norout512_208 vdd vss PBulkLine NBulkLine) twonor
//nor_512_209 (out_512 vdd norout512_209 vdd vss PBulkLine NBulkLine) twonor
//nor_512_210 (out_512 vdd norout512_210 vdd vss PBulkLine NBulkLine) twonor
//nor_512_211 (out_512 vdd norout512_211 vdd vss PBulkLine NBulkLine) twonor
//nor_512_212 (out_512 vdd norout512_212 vdd vss PBulkLine NBulkLine) twonor
//nor_512_213 (out_512 vdd norout512_213 vdd vss PBulkLine NBulkLine) twonor
//nor_512_214 (out_512 vdd norout512_214 vdd vss PBulkLine NBulkLine) twonor
//nor_512_215 (out_512 vdd norout512_215 vdd vss PBulkLine NBulkLine) twonor
//nor_512_216 (out_512 vdd norout512_216 vdd vss PBulkLine NBulkLine) twonor
//nor_512_217 (out_512 vdd norout512_217 vdd vss PBulkLine NBulkLine) twonor
//nor_512_218 (out_512 vdd norout512_218 vdd vss PBulkLine NBulkLine) twonor
//nor_512_219 (out_512 vdd norout512_219 vdd vss PBulkLine NBulkLine) twonor
//nor_512_220 (out_512 vdd norout512_220 vdd vss PBulkLine NBulkLine) twonor
//nor_512_221 (out_512 vdd norout512_221 vdd vss PBulkLine NBulkLine) twonor
//nor_512_222 (out_512 vdd norout512_222 vdd vss PBulkLine NBulkLine) twonor
//nor_512_223 (out_512 vdd norout512_223 vdd vss PBulkLine NBulkLine) twonor
//nor_512_224 (out_512 vdd norout512_224 vdd vss PBulkLine NBulkLine) twonor
//nor_512_225 (out_512 vdd norout512_225 vdd vss PBulkLine NBulkLine) twonor
//nor_512_226 (out_512 vdd norout512_226 vdd vss PBulkLine NBulkLine) twonor
//nor_512_227 (out_512 vdd norout512_227 vdd vss PBulkLine NBulkLine) twonor
//nor_512_228 (out_512 vdd norout512_228 vdd vss PBulkLine NBulkLine) twonor
//nor_512_229 (out_512 vdd norout512_229 vdd vss PBulkLine NBulkLine) twonor
//nor_512_230 (out_512 vdd norout512_230 vdd vss PBulkLine NBulkLine) twonor
//nor_512_231 (out_512 vdd norout512_231 vdd vss PBulkLine NBulkLine) twonor
//nor_512_232 (out_512 vdd norout512_232 vdd vss PBulkLine NBulkLine) twonor
//nor_512_233 (out_512 vdd norout512_233 vdd vss PBulkLine NBulkLine) twonor
//nor_512_234 (out_512 vdd norout512_234 vdd vss PBulkLine NBulkLine) twonor
//nor_512_235 (out_512 vdd norout512_235 vdd vss PBulkLine NBulkLine) twonor
//nor_512_236 (out_512 vdd norout512_236 vdd vss PBulkLine NBulkLine) twonor
//nor_512_237 (out_512 vdd norout512_237 vdd vss PBulkLine NBulkLine) twonor
//nor_512_238 (out_512 vdd norout512_238 vdd vss PBulkLine NBulkLine) twonor
//nor_512_239 (out_512 vdd norout512_239 vdd vss PBulkLine NBulkLine) twonor
//nor_512_240 (out_512 vdd norout512_240 vdd vss PBulkLine NBulkLine) twonor
//nor_512_241 (out_512 vdd norout512_241 vdd vss PBulkLine NBulkLine) twonor
//nor_512_242 (out_512 vdd norout512_242 vdd vss PBulkLine NBulkLine) twonor
//nor_512_243 (out_512 vdd norout512_243 vdd vss PBulkLine NBulkLine) twonor
//nor_512_244 (out_512 vdd norout512_244 vdd vss PBulkLine NBulkLine) twonor
//nor_512_245 (out_512 vdd norout512_245 vdd vss PBulkLine NBulkLine) twonor
//nor_512_246 (out_512 vdd norout512_246 vdd vss PBulkLine NBulkLine) twonor
//nor_512_247 (out_512 vdd norout512_247 vdd vss PBulkLine NBulkLine) twonor
//nor_512_248 (out_512 vdd norout512_248 vdd vss PBulkLine NBulkLine) twonor
//nor_512_249 (out_512 vdd norout512_249 vdd vss PBulkLine NBulkLine) twonor
//nor_512_250 (out_512 vdd norout512_250 vdd vss PBulkLine NBulkLine) twonor
//nor_512_251 (out_512 vdd norout512_251 vdd vss PBulkLine NBulkLine) twonor
//nor_512_252 (out_512 vdd norout512_252 vdd vss PBulkLine NBulkLine) twonor
//nor_512_253 (out_512 vdd norout512_253 vdd vss PBulkLine NBulkLine) twonor
//nor_512_254 (out_512 vdd norout512_254 vdd vss PBulkLine NBulkLine) twonor
//nor_512_255 (out_512 vdd norout512_255 vdd vss PBulkLine NBulkLine) twonor
//nor_512_256 (out_512 vdd norout512_256 vdd vss PBulkLine NBulkLine) twonor
//nor_512_257 (out_512 vdd norout512_257 vdd vss PBulkLine NBulkLine) twonor
//nor_512_258 (out_512 vdd norout512_258 vdd vss PBulkLine NBulkLine) twonor
//nor_512_259 (out_512 vdd norout512_259 vdd vss PBulkLine NBulkLine) twonor
//nor_512_260 (out_512 vdd norout512_260 vdd vss PBulkLine NBulkLine) twonor
//nor_512_261 (out_512 vdd norout512_261 vdd vss PBulkLine NBulkLine) twonor
//nor_512_262 (out_512 vdd norout512_262 vdd vss PBulkLine NBulkLine) twonor
//nor_512_263 (out_512 vdd norout512_263 vdd vss PBulkLine NBulkLine) twonor
//nor_512_264 (out_512 vdd norout512_264 vdd vss PBulkLine NBulkLine) twonor
//nor_512_265 (out_512 vdd norout512_265 vdd vss PBulkLine NBulkLine) twonor
//nor_512_266 (out_512 vdd norout512_266 vdd vss PBulkLine NBulkLine) twonor
//nor_512_267 (out_512 vdd norout512_267 vdd vss PBulkLine NBulkLine) twonor
//nor_512_268 (out_512 vdd norout512_268 vdd vss PBulkLine NBulkLine) twonor
//nor_512_269 (out_512 vdd norout512_269 vdd vss PBulkLine NBulkLine) twonor
//nor_512_270 (out_512 vdd norout512_270 vdd vss PBulkLine NBulkLine) twonor
//nor_512_271 (out_512 vdd norout512_271 vdd vss PBulkLine NBulkLine) twonor
//nor_512_272 (out_512 vdd norout512_272 vdd vss PBulkLine NBulkLine) twonor
//nor_512_273 (out_512 vdd norout512_273 vdd vss PBulkLine NBulkLine) twonor
//nor_512_274 (out_512 vdd norout512_274 vdd vss PBulkLine NBulkLine) twonor
//nor_512_275 (out_512 vdd norout512_275 vdd vss PBulkLine NBulkLine) twonor
//nor_512_276 (out_512 vdd norout512_276 vdd vss PBulkLine NBulkLine) twonor
//nor_512_277 (out_512 vdd norout512_277 vdd vss PBulkLine NBulkLine) twonor
//nor_512_278 (out_512 vdd norout512_278 vdd vss PBulkLine NBulkLine) twonor
//nor_512_279 (out_512 vdd norout512_279 vdd vss PBulkLine NBulkLine) twonor
//nor_512_280 (out_512 vdd norout512_280 vdd vss PBulkLine NBulkLine) twonor
//nor_512_281 (out_512 vdd norout512_281 vdd vss PBulkLine NBulkLine) twonor
//nor_512_282 (out_512 vdd norout512_282 vdd vss PBulkLine NBulkLine) twonor
//nor_512_283 (out_512 vdd norout512_283 vdd vss PBulkLine NBulkLine) twonor
//nor_512_284 (out_512 vdd norout512_284 vdd vss PBulkLine NBulkLine) twonor
//nor_512_285 (out_512 vdd norout512_285 vdd vss PBulkLine NBulkLine) twonor
//nor_512_286 (out_512 vdd norout512_286 vdd vss PBulkLine NBulkLine) twonor
//nor_512_287 (out_512 vdd norout512_287 vdd vss PBulkLine NBulkLine) twonor
//nor_512_288 (out_512 vdd norout512_288 vdd vss PBulkLine NBulkLine) twonor
//nor_512_289 (out_512 vdd norout512_289 vdd vss PBulkLine NBulkLine) twonor
//nor_512_290 (out_512 vdd norout512_290 vdd vss PBulkLine NBulkLine) twonor
//nor_512_291 (out_512 vdd norout512_291 vdd vss PBulkLine NBulkLine) twonor
//nor_512_292 (out_512 vdd norout512_292 vdd vss PBulkLine NBulkLine) twonor
//nor_512_293 (out_512 vdd norout512_293 vdd vss PBulkLine NBulkLine) twonor
//nor_512_294 (out_512 vdd norout512_294 vdd vss PBulkLine NBulkLine) twonor
//nor_512_295 (out_512 vdd norout512_295 vdd vss PBulkLine NBulkLine) twonor
//nor_512_296 (out_512 vdd norout512_296 vdd vss PBulkLine NBulkLine) twonor
//nor_512_297 (out_512 vdd norout512_297 vdd vss PBulkLine NBulkLine) twonor
//nor_512_298 (out_512 vdd norout512_298 vdd vss PBulkLine NBulkLine) twonor
//nor_512_299 (out_512 vdd norout512_299 vdd vss PBulkLine NBulkLine) twonor
//nor_512_300 (out_512 vdd norout512_300 vdd vss PBulkLine NBulkLine) twonor
//nor_512_301 (out_512 vdd norout512_301 vdd vss PBulkLine NBulkLine) twonor
//nor_512_302 (out_512 vdd norout512_302 vdd vss PBulkLine NBulkLine) twonor
//nor_512_303 (out_512 vdd norout512_303 vdd vss PBulkLine NBulkLine) twonor
//nor_512_304 (out_512 vdd norout512_304 vdd vss PBulkLine NBulkLine) twonor
//nor_512_305 (out_512 vdd norout512_305 vdd vss PBulkLine NBulkLine) twonor
//nor_512_306 (out_512 vdd norout512_306 vdd vss PBulkLine NBulkLine) twonor
//nor_512_307 (out_512 vdd norout512_307 vdd vss PBulkLine NBulkLine) twonor
//nor_512_308 (out_512 vdd norout512_308 vdd vss PBulkLine NBulkLine) twonor
//nor_512_309 (out_512 vdd norout512_309 vdd vss PBulkLine NBulkLine) twonor
//nor_512_310 (out_512 vdd norout512_310 vdd vss PBulkLine NBulkLine) twonor
//nor_512_311 (out_512 vdd norout512_311 vdd vss PBulkLine NBulkLine) twonor
//nor_512_312 (out_512 vdd norout512_312 vdd vss PBulkLine NBulkLine) twonor
//nor_512_313 (out_512 vdd norout512_313 vdd vss PBulkLine NBulkLine) twonor
//nor_512_314 (out_512 vdd norout512_314 vdd vss PBulkLine NBulkLine) twonor
//nor_512_315 (out_512 vdd norout512_315 vdd vss PBulkLine NBulkLine) twonor
//nor_512_316 (out_512 vdd norout512_316 vdd vss PBulkLine NBulkLine) twonor
//nor_512_317 (out_512 vdd norout512_317 vdd vss PBulkLine NBulkLine) twonor
//nor_512_318 (out_512 vdd norout512_318 vdd vss PBulkLine NBulkLine) twonor
//nor_512_319 (out_512 vdd norout512_319 vdd vss PBulkLine NBulkLine) twonor
//nor_512_320 (out_512 vdd norout512_320 vdd vss PBulkLine NBulkLine) twonor
//nor_512_321 (out_512 vdd norout512_321 vdd vss PBulkLine NBulkLine) twonor
//nor_512_322 (out_512 vdd norout512_322 vdd vss PBulkLine NBulkLine) twonor
//nor_512_323 (out_512 vdd norout512_323 vdd vss PBulkLine NBulkLine) twonor
//nor_512_324 (out_512 vdd norout512_324 vdd vss PBulkLine NBulkLine) twonor
//nor_512_325 (out_512 vdd norout512_325 vdd vss PBulkLine NBulkLine) twonor
//nor_512_326 (out_512 vdd norout512_326 vdd vss PBulkLine NBulkLine) twonor
//nor_512_327 (out_512 vdd norout512_327 vdd vss PBulkLine NBulkLine) twonor
//nor_512_328 (out_512 vdd norout512_328 vdd vss PBulkLine NBulkLine) twonor
//nor_512_329 (out_512 vdd norout512_329 vdd vss PBulkLine NBulkLine) twonor
//nor_512_330 (out_512 vdd norout512_330 vdd vss PBulkLine NBulkLine) twonor
//nor_512_331 (out_512 vdd norout512_331 vdd vss PBulkLine NBulkLine) twonor
//nor_512_332 (out_512 vdd norout512_332 vdd vss PBulkLine NBulkLine) twonor
//nor_512_333 (out_512 vdd norout512_333 vdd vss PBulkLine NBulkLine) twonor
//nor_512_334 (out_512 vdd norout512_334 vdd vss PBulkLine NBulkLine) twonor
//nor_512_335 (out_512 vdd norout512_335 vdd vss PBulkLine NBulkLine) twonor
//nor_512_336 (out_512 vdd norout512_336 vdd vss PBulkLine NBulkLine) twonor
//nor_512_337 (out_512 vdd norout512_337 vdd vss PBulkLine NBulkLine) twonor
//nor_512_338 (out_512 vdd norout512_338 vdd vss PBulkLine NBulkLine) twonor
//nor_512_339 (out_512 vdd norout512_339 vdd vss PBulkLine NBulkLine) twonor
//nor_512_340 (out_512 vdd norout512_340 vdd vss PBulkLine NBulkLine) twonor
//nor_512_341 (out_512 vdd norout512_341 vdd vss PBulkLine NBulkLine) twonor
//nor_512_342 (out_512 vdd norout512_342 vdd vss PBulkLine NBulkLine) twonor
//nor_512_343 (out_512 vdd norout512_343 vdd vss PBulkLine NBulkLine) twonor
//nor_512_344 (out_512 vdd norout512_344 vdd vss PBulkLine NBulkLine) twonor
//nor_512_345 (out_512 vdd norout512_345 vdd vss PBulkLine NBulkLine) twonor
//nor_512_346 (out_512 vdd norout512_346 vdd vss PBulkLine NBulkLine) twonor
//nor_512_347 (out_512 vdd norout512_347 vdd vss PBulkLine NBulkLine) twonor
//nor_512_348 (out_512 vdd norout512_348 vdd vss PBulkLine NBulkLine) twonor
//nor_512_349 (out_512 vdd norout512_349 vdd vss PBulkLine NBulkLine) twonor
//nor_512_350 (out_512 vdd norout512_350 vdd vss PBulkLine NBulkLine) twonor
//nor_512_351 (out_512 vdd norout512_351 vdd vss PBulkLine NBulkLine) twonor
//nor_512_352 (out_512 vdd norout512_352 vdd vss PBulkLine NBulkLine) twonor
//nor_512_353 (out_512 vdd norout512_353 vdd vss PBulkLine NBulkLine) twonor
//nor_512_354 (out_512 vdd norout512_354 vdd vss PBulkLine NBulkLine) twonor
//nor_512_355 (out_512 vdd norout512_355 vdd vss PBulkLine NBulkLine) twonor
//nor_512_356 (out_512 vdd norout512_356 vdd vss PBulkLine NBulkLine) twonor
//nor_512_357 (out_512 vdd norout512_357 vdd vss PBulkLine NBulkLine) twonor
//nor_512_358 (out_512 vdd norout512_358 vdd vss PBulkLine NBulkLine) twonor
//nor_512_359 (out_512 vdd norout512_359 vdd vss PBulkLine NBulkLine) twonor
//nor_512_360 (out_512 vdd norout512_360 vdd vss PBulkLine NBulkLine) twonor
//nor_512_361 (out_512 vdd norout512_361 vdd vss PBulkLine NBulkLine) twonor
//nor_512_362 (out_512 vdd norout512_362 vdd vss PBulkLine NBulkLine) twonor
//nor_512_363 (out_512 vdd norout512_363 vdd vss PBulkLine NBulkLine) twonor
//nor_512_364 (out_512 vdd norout512_364 vdd vss PBulkLine NBulkLine) twonor
//nor_512_365 (out_512 vdd norout512_365 vdd vss PBulkLine NBulkLine) twonor
//nor_512_366 (out_512 vdd norout512_366 vdd vss PBulkLine NBulkLine) twonor
//nor_512_367 (out_512 vdd norout512_367 vdd vss PBulkLine NBulkLine) twonor
//nor_512_368 (out_512 vdd norout512_368 vdd vss PBulkLine NBulkLine) twonor
//nor_512_369 (out_512 vdd norout512_369 vdd vss PBulkLine NBulkLine) twonor
//nor_512_370 (out_512 vdd norout512_370 vdd vss PBulkLine NBulkLine) twonor
//nor_512_371 (out_512 vdd norout512_371 vdd vss PBulkLine NBulkLine) twonor
//nor_512_372 (out_512 vdd norout512_372 vdd vss PBulkLine NBulkLine) twonor
//nor_512_373 (out_512 vdd norout512_373 vdd vss PBulkLine NBulkLine) twonor
//nor_512_374 (out_512 vdd norout512_374 vdd vss PBulkLine NBulkLine) twonor
//nor_512_375 (out_512 vdd norout512_375 vdd vss PBulkLine NBulkLine) twonor
//nor_512_376 (out_512 vdd norout512_376 vdd vss PBulkLine NBulkLine) twonor
//nor_512_377 (out_512 vdd norout512_377 vdd vss PBulkLine NBulkLine) twonor
//nor_512_378 (out_512 vdd norout512_378 vdd vss PBulkLine NBulkLine) twonor
//nor_512_379 (out_512 vdd norout512_379 vdd vss PBulkLine NBulkLine) twonor
//nor_512_380 (out_512 vdd norout512_380 vdd vss PBulkLine NBulkLine) twonor
//nor_512_381 (out_512 vdd norout512_381 vdd vss PBulkLine NBulkLine) twonor
//nor_512_382 (out_512 vdd norout512_382 vdd vss PBulkLine NBulkLine) twonor
//nor_512_383 (out_512 vdd norout512_383 vdd vss PBulkLine NBulkLine) twonor
//nor_512_384 (out_512 vdd norout512_384 vdd vss PBulkLine NBulkLine) twonor
//nor_512_385 (out_512 vdd norout512_385 vdd vss PBulkLine NBulkLine) twonor
//nor_512_386 (out_512 vdd norout512_386 vdd vss PBulkLine NBulkLine) twonor
//nor_512_387 (out_512 vdd norout512_387 vdd vss PBulkLine NBulkLine) twonor
//nor_512_388 (out_512 vdd norout512_388 vdd vss PBulkLine NBulkLine) twonor
//nor_512_389 (out_512 vdd norout512_389 vdd vss PBulkLine NBulkLine) twonor
//nor_512_390 (out_512 vdd norout512_390 vdd vss PBulkLine NBulkLine) twonor
//nor_512_391 (out_512 vdd norout512_391 vdd vss PBulkLine NBulkLine) twonor
//nor_512_392 (out_512 vdd norout512_392 vdd vss PBulkLine NBulkLine) twonor
//nor_512_393 (out_512 vdd norout512_393 vdd vss PBulkLine NBulkLine) twonor
//nor_512_394 (out_512 vdd norout512_394 vdd vss PBulkLine NBulkLine) twonor
//nor_512_395 (out_512 vdd norout512_395 vdd vss PBulkLine NBulkLine) twonor
//nor_512_396 (out_512 vdd norout512_396 vdd vss PBulkLine NBulkLine) twonor
//nor_512_397 (out_512 vdd norout512_397 vdd vss PBulkLine NBulkLine) twonor
//nor_512_398 (out_512 vdd norout512_398 vdd vss PBulkLine NBulkLine) twonor
//nor_512_399 (out_512 vdd norout512_399 vdd vss PBulkLine NBulkLine) twonor
//nor_512_400 (out_512 vdd norout512_400 vdd vss PBulkLine NBulkLine) twonor
//nor_512_401 (out_512 vdd norout512_401 vdd vss PBulkLine NBulkLine) twonor
//nor_512_402 (out_512 vdd norout512_402 vdd vss PBulkLine NBulkLine) twonor
//nor_512_403 (out_512 vdd norout512_403 vdd vss PBulkLine NBulkLine) twonor
//nor_512_404 (out_512 vdd norout512_404 vdd vss PBulkLine NBulkLine) twonor
//nor_512_405 (out_512 vdd norout512_405 vdd vss PBulkLine NBulkLine) twonor
//nor_512_406 (out_512 vdd norout512_406 vdd vss PBulkLine NBulkLine) twonor
//nor_512_407 (out_512 vdd norout512_407 vdd vss PBulkLine NBulkLine) twonor
//nor_512_408 (out_512 vdd norout512_408 vdd vss PBulkLine NBulkLine) twonor
//nor_512_409 (out_512 vdd norout512_409 vdd vss PBulkLine NBulkLine) twonor
//nor_512_410 (out_512 vdd norout512_410 vdd vss PBulkLine NBulkLine) twonor
//nor_512_411 (out_512 vdd norout512_411 vdd vss PBulkLine NBulkLine) twonor
//nor_512_412 (out_512 vdd norout512_412 vdd vss PBulkLine NBulkLine) twonor
//nor_512_413 (out_512 vdd norout512_413 vdd vss PBulkLine NBulkLine) twonor
//nor_512_414 (out_512 vdd norout512_414 vdd vss PBulkLine NBulkLine) twonor
//nor_512_415 (out_512 vdd norout512_415 vdd vss PBulkLine NBulkLine) twonor
//nor_512_416 (out_512 vdd norout512_416 vdd vss PBulkLine NBulkLine) twonor
//nor_512_417 (out_512 vdd norout512_417 vdd vss PBulkLine NBulkLine) twonor
//nor_512_418 (out_512 vdd norout512_418 vdd vss PBulkLine NBulkLine) twonor
//nor_512_419 (out_512 vdd norout512_419 vdd vss PBulkLine NBulkLine) twonor
//nor_512_420 (out_512 vdd norout512_420 vdd vss PBulkLine NBulkLine) twonor
//nor_512_421 (out_512 vdd norout512_421 vdd vss PBulkLine NBulkLine) twonor
//nor_512_422 (out_512 vdd norout512_422 vdd vss PBulkLine NBulkLine) twonor
//nor_512_423 (out_512 vdd norout512_423 vdd vss PBulkLine NBulkLine) twonor
//nor_512_424 (out_512 vdd norout512_424 vdd vss PBulkLine NBulkLine) twonor
//nor_512_425 (out_512 vdd norout512_425 vdd vss PBulkLine NBulkLine) twonor
//nor_512_426 (out_512 vdd norout512_426 vdd vss PBulkLine NBulkLine) twonor
//nor_512_427 (out_512 vdd norout512_427 vdd vss PBulkLine NBulkLine) twonor
//nor_512_428 (out_512 vdd norout512_428 vdd vss PBulkLine NBulkLine) twonor
//nor_512_429 (out_512 vdd norout512_429 vdd vss PBulkLine NBulkLine) twonor
//nor_512_430 (out_512 vdd norout512_430 vdd vss PBulkLine NBulkLine) twonor
//nor_512_431 (out_512 vdd norout512_431 vdd vss PBulkLine NBulkLine) twonor
//nor_512_432 (out_512 vdd norout512_432 vdd vss PBulkLine NBulkLine) twonor
//nor_512_433 (out_512 vdd norout512_433 vdd vss PBulkLine NBulkLine) twonor
//nor_512_434 (out_512 vdd norout512_434 vdd vss PBulkLine NBulkLine) twonor
//nor_512_435 (out_512 vdd norout512_435 vdd vss PBulkLine NBulkLine) twonor
//nor_512_436 (out_512 vdd norout512_436 vdd vss PBulkLine NBulkLine) twonor
//nor_512_437 (out_512 vdd norout512_437 vdd vss PBulkLine NBulkLine) twonor
//nor_512_438 (out_512 vdd norout512_438 vdd vss PBulkLine NBulkLine) twonor
//nor_512_439 (out_512 vdd norout512_439 vdd vss PBulkLine NBulkLine) twonor
//nor_512_440 (out_512 vdd norout512_440 vdd vss PBulkLine NBulkLine) twonor
//nor_512_441 (out_512 vdd norout512_441 vdd vss PBulkLine NBulkLine) twonor
//nor_512_442 (out_512 vdd norout512_442 vdd vss PBulkLine NBulkLine) twonor
//nor_512_443 (out_512 vdd norout512_443 vdd vss PBulkLine NBulkLine) twonor
//nor_512_444 (out_512 vdd norout512_444 vdd vss PBulkLine NBulkLine) twonor
//nor_512_445 (out_512 vdd norout512_445 vdd vss PBulkLine NBulkLine) twonor
//nor_512_446 (out_512 vdd norout512_446 vdd vss PBulkLine NBulkLine) twonor
//nor_512_447 (out_512 vdd norout512_447 vdd vss PBulkLine NBulkLine) twonor
//nor_512_448 (out_512 vdd norout512_448 vdd vss PBulkLine NBulkLine) twonor
//nor_512_449 (out_512 vdd norout512_449 vdd vss PBulkLine NBulkLine) twonor
//nor_512_450 (out_512 vdd norout512_450 vdd vss PBulkLine NBulkLine) twonor
//nor_512_451 (out_512 vdd norout512_451 vdd vss PBulkLine NBulkLine) twonor
//nor_512_452 (out_512 vdd norout512_452 vdd vss PBulkLine NBulkLine) twonor
//nor_512_453 (out_512 vdd norout512_453 vdd vss PBulkLine NBulkLine) twonor
//nor_512_454 (out_512 vdd norout512_454 vdd vss PBulkLine NBulkLine) twonor
//nor_512_455 (out_512 vdd norout512_455 vdd vss PBulkLine NBulkLine) twonor
//nor_512_456 (out_512 vdd norout512_456 vdd vss PBulkLine NBulkLine) twonor
//nor_512_457 (out_512 vdd norout512_457 vdd vss PBulkLine NBulkLine) twonor
//nor_512_458 (out_512 vdd norout512_458 vdd vss PBulkLine NBulkLine) twonor
//nor_512_459 (out_512 vdd norout512_459 vdd vss PBulkLine NBulkLine) twonor
//nor_512_460 (out_512 vdd norout512_460 vdd vss PBulkLine NBulkLine) twonor
//nor_512_461 (out_512 vdd norout512_461 vdd vss PBulkLine NBulkLine) twonor
//nor_512_462 (out_512 vdd norout512_462 vdd vss PBulkLine NBulkLine) twonor
//nor_512_463 (out_512 vdd norout512_463 vdd vss PBulkLine NBulkLine) twonor
//nor_512_464 (out_512 vdd norout512_464 vdd vss PBulkLine NBulkLine) twonor
//nor_512_465 (out_512 vdd norout512_465 vdd vss PBulkLine NBulkLine) twonor
//nor_512_466 (out_512 vdd norout512_466 vdd vss PBulkLine NBulkLine) twonor
//nor_512_467 (out_512 vdd norout512_467 vdd vss PBulkLine NBulkLine) twonor
//nor_512_468 (out_512 vdd norout512_468 vdd vss PBulkLine NBulkLine) twonor
//nor_512_469 (out_512 vdd norout512_469 vdd vss PBulkLine NBulkLine) twonor
//nor_512_470 (out_512 vdd norout512_470 vdd vss PBulkLine NBulkLine) twonor
//nor_512_471 (out_512 vdd norout512_471 vdd vss PBulkLine NBulkLine) twonor
//nor_512_472 (out_512 vdd norout512_472 vdd vss PBulkLine NBulkLine) twonor
//nor_512_473 (out_512 vdd norout512_473 vdd vss PBulkLine NBulkLine) twonor
//nor_512_474 (out_512 vdd norout512_474 vdd vss PBulkLine NBulkLine) twonor
//nor_512_475 (out_512 vdd norout512_475 vdd vss PBulkLine NBulkLine) twonor
//nor_512_476 (out_512 vdd norout512_476 vdd vss PBulkLine NBulkLine) twonor
//nor_512_477 (out_512 vdd norout512_477 vdd vss PBulkLine NBulkLine) twonor
//nor_512_478 (out_512 vdd norout512_478 vdd vss PBulkLine NBulkLine) twonor
//nor_512_479 (out_512 vdd norout512_479 vdd vss PBulkLine NBulkLine) twonor
//nor_512_480 (out_512 vdd norout512_480 vdd vss PBulkLine NBulkLine) twonor
//nor_512_481 (out_512 vdd norout512_481 vdd vss PBulkLine NBulkLine) twonor
//nor_512_482 (out_512 vdd norout512_482 vdd vss PBulkLine NBulkLine) twonor
//nor_512_483 (out_512 vdd norout512_483 vdd vss PBulkLine NBulkLine) twonor
//nor_512_484 (out_512 vdd norout512_484 vdd vss PBulkLine NBulkLine) twonor
//nor_512_485 (out_512 vdd norout512_485 vdd vss PBulkLine NBulkLine) twonor
//nor_512_486 (out_512 vdd norout512_486 vdd vss PBulkLine NBulkLine) twonor
//nor_512_487 (out_512 vdd norout512_487 vdd vss PBulkLine NBulkLine) twonor
//nor_512_488 (out_512 vdd norout512_488 vdd vss PBulkLine NBulkLine) twonor
//nor_512_489 (out_512 vdd norout512_489 vdd vss PBulkLine NBulkLine) twonor
//nor_512_490 (out_512 vdd norout512_490 vdd vss PBulkLine NBulkLine) twonor
//nor_512_491 (out_512 vdd norout512_491 vdd vss PBulkLine NBulkLine) twonor
//nor_512_492 (out_512 vdd norout512_492 vdd vss PBulkLine NBulkLine) twonor
//nor_512_493 (out_512 vdd norout512_493 vdd vss PBulkLine NBulkLine) twonor
//nor_512_494 (out_512 vdd norout512_494 vdd vss PBulkLine NBulkLine) twonor
//nor_512_495 (out_512 vdd norout512_495 vdd vss PBulkLine NBulkLine) twonor
//nor_512_496 (out_512 vdd norout512_496 vdd vss PBulkLine NBulkLine) twonor
//nor_512_497 (out_512 vdd norout512_497 vdd vss PBulkLine NBulkLine) twonor
//nor_512_498 (out_512 vdd norout512_498 vdd vss PBulkLine NBulkLine) twonor
//nor_512_499 (out_512 vdd norout512_499 vdd vss PBulkLine NBulkLine) twonor
//nor_512_500 (out_512 vdd norout512_500 vdd vss PBulkLine NBulkLine) twonor
//nor_512_501 (out_512 vdd norout512_501 vdd vss PBulkLine NBulkLine) twonor
//nor_512_502 (out_512 vdd norout512_502 vdd vss PBulkLine NBulkLine) twonor
//nor_512_503 (out_512 vdd norout512_503 vdd vss PBulkLine NBulkLine) twonor
//nor_512_504 (out_512 vdd norout512_504 vdd vss PBulkLine NBulkLine) twonor
//nor_512_505 (out_512 vdd norout512_505 vdd vss PBulkLine NBulkLine) twonor
//nor_512_506 (out_512 vdd norout512_506 vdd vss PBulkLine NBulkLine) twonor
//nor_512_507 (out_512 vdd norout512_507 vdd vss PBulkLine NBulkLine) twonor
//nor_512_508 (out_512 vdd norout512_508 vdd vss PBulkLine NBulkLine) twonor
//nor_512_509 (out_512 vdd norout512_509 vdd vss PBulkLine NBulkLine) twonor
//nor_512_510 (out_512 vdd norout512_510 vdd vss PBulkLine NBulkLine) twonor
//nor_512_511 (out_512 vdd norout512_511 vdd vss PBulkLine NBulkLine) twonor
//nor_512_512 (out_512 vdd norout512_512 vdd vss PBulkLine NBulkLine) twonor
cPar_512 out_512 vss capacitor c=9.216e-14
xNot_1024_a (in temp_1024 vdd vss PBulkLine NBulkLine) inverter mult=1
xNot_1024_b (temp_1024 out_1024 vdd vss PBulkLine NBulkLine) inverter mult=1
//nor_1024_1 (out_1024 vdd norout1024_1 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_2 (out_1024 vdd norout1024_2 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_3 (out_1024 vdd norout1024_3 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_4 (out_1024 vdd norout1024_4 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_5 (out_1024 vdd norout1024_5 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_6 (out_1024 vdd norout1024_6 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_7 (out_1024 vdd norout1024_7 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_8 (out_1024 vdd norout1024_8 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_9 (out_1024 vdd norout1024_9 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_10 (out_1024 vdd norout1024_10 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_11 (out_1024 vdd norout1024_11 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_12 (out_1024 vdd norout1024_12 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_13 (out_1024 vdd norout1024_13 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_14 (out_1024 vdd norout1024_14 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_15 (out_1024 vdd norout1024_15 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_16 (out_1024 vdd norout1024_16 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_17 (out_1024 vdd norout1024_17 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_18 (out_1024 vdd norout1024_18 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_19 (out_1024 vdd norout1024_19 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_20 (out_1024 vdd norout1024_20 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_21 (out_1024 vdd norout1024_21 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_22 (out_1024 vdd norout1024_22 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_23 (out_1024 vdd norout1024_23 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_24 (out_1024 vdd norout1024_24 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_25 (out_1024 vdd norout1024_25 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_26 (out_1024 vdd norout1024_26 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_27 (out_1024 vdd norout1024_27 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_28 (out_1024 vdd norout1024_28 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_29 (out_1024 vdd norout1024_29 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_30 (out_1024 vdd norout1024_30 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_31 (out_1024 vdd norout1024_31 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_32 (out_1024 vdd norout1024_32 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_33 (out_1024 vdd norout1024_33 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_34 (out_1024 vdd norout1024_34 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_35 (out_1024 vdd norout1024_35 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_36 (out_1024 vdd norout1024_36 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_37 (out_1024 vdd norout1024_37 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_38 (out_1024 vdd norout1024_38 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_39 (out_1024 vdd norout1024_39 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_40 (out_1024 vdd norout1024_40 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_41 (out_1024 vdd norout1024_41 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_42 (out_1024 vdd norout1024_42 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_43 (out_1024 vdd norout1024_43 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_44 (out_1024 vdd norout1024_44 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_45 (out_1024 vdd norout1024_45 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_46 (out_1024 vdd norout1024_46 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_47 (out_1024 vdd norout1024_47 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_48 (out_1024 vdd norout1024_48 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_49 (out_1024 vdd norout1024_49 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_50 (out_1024 vdd norout1024_50 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_51 (out_1024 vdd norout1024_51 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_52 (out_1024 vdd norout1024_52 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_53 (out_1024 vdd norout1024_53 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_54 (out_1024 vdd norout1024_54 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_55 (out_1024 vdd norout1024_55 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_56 (out_1024 vdd norout1024_56 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_57 (out_1024 vdd norout1024_57 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_58 (out_1024 vdd norout1024_58 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_59 (out_1024 vdd norout1024_59 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_60 (out_1024 vdd norout1024_60 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_61 (out_1024 vdd norout1024_61 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_62 (out_1024 vdd norout1024_62 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_63 (out_1024 vdd norout1024_63 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_64 (out_1024 vdd norout1024_64 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_65 (out_1024 vdd norout1024_65 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_66 (out_1024 vdd norout1024_66 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_67 (out_1024 vdd norout1024_67 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_68 (out_1024 vdd norout1024_68 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_69 (out_1024 vdd norout1024_69 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_70 (out_1024 vdd norout1024_70 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_71 (out_1024 vdd norout1024_71 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_72 (out_1024 vdd norout1024_72 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_73 (out_1024 vdd norout1024_73 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_74 (out_1024 vdd norout1024_74 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_75 (out_1024 vdd norout1024_75 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_76 (out_1024 vdd norout1024_76 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_77 (out_1024 vdd norout1024_77 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_78 (out_1024 vdd norout1024_78 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_79 (out_1024 vdd norout1024_79 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_80 (out_1024 vdd norout1024_80 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_81 (out_1024 vdd norout1024_81 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_82 (out_1024 vdd norout1024_82 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_83 (out_1024 vdd norout1024_83 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_84 (out_1024 vdd norout1024_84 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_85 (out_1024 vdd norout1024_85 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_86 (out_1024 vdd norout1024_86 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_87 (out_1024 vdd norout1024_87 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_88 (out_1024 vdd norout1024_88 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_89 (out_1024 vdd norout1024_89 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_90 (out_1024 vdd norout1024_90 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_91 (out_1024 vdd norout1024_91 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_92 (out_1024 vdd norout1024_92 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_93 (out_1024 vdd norout1024_93 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_94 (out_1024 vdd norout1024_94 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_95 (out_1024 vdd norout1024_95 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_96 (out_1024 vdd norout1024_96 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_97 (out_1024 vdd norout1024_97 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_98 (out_1024 vdd norout1024_98 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_99 (out_1024 vdd norout1024_99 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_100 (out_1024 vdd norout1024_100 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_101 (out_1024 vdd norout1024_101 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_102 (out_1024 vdd norout1024_102 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_103 (out_1024 vdd norout1024_103 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_104 (out_1024 vdd norout1024_104 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_105 (out_1024 vdd norout1024_105 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_106 (out_1024 vdd norout1024_106 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_107 (out_1024 vdd norout1024_107 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_108 (out_1024 vdd norout1024_108 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_109 (out_1024 vdd norout1024_109 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_110 (out_1024 vdd norout1024_110 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_111 (out_1024 vdd norout1024_111 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_112 (out_1024 vdd norout1024_112 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_113 (out_1024 vdd norout1024_113 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_114 (out_1024 vdd norout1024_114 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_115 (out_1024 vdd norout1024_115 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_116 (out_1024 vdd norout1024_116 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_117 (out_1024 vdd norout1024_117 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_118 (out_1024 vdd norout1024_118 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_119 (out_1024 vdd norout1024_119 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_120 (out_1024 vdd norout1024_120 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_121 (out_1024 vdd norout1024_121 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_122 (out_1024 vdd norout1024_122 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_123 (out_1024 vdd norout1024_123 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_124 (out_1024 vdd norout1024_124 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_125 (out_1024 vdd norout1024_125 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_126 (out_1024 vdd norout1024_126 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_127 (out_1024 vdd norout1024_127 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_128 (out_1024 vdd norout1024_128 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_129 (out_1024 vdd norout1024_129 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_130 (out_1024 vdd norout1024_130 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_131 (out_1024 vdd norout1024_131 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_132 (out_1024 vdd norout1024_132 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_133 (out_1024 vdd norout1024_133 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_134 (out_1024 vdd norout1024_134 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_135 (out_1024 vdd norout1024_135 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_136 (out_1024 vdd norout1024_136 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_137 (out_1024 vdd norout1024_137 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_138 (out_1024 vdd norout1024_138 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_139 (out_1024 vdd norout1024_139 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_140 (out_1024 vdd norout1024_140 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_141 (out_1024 vdd norout1024_141 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_142 (out_1024 vdd norout1024_142 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_143 (out_1024 vdd norout1024_143 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_144 (out_1024 vdd norout1024_144 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_145 (out_1024 vdd norout1024_145 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_146 (out_1024 vdd norout1024_146 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_147 (out_1024 vdd norout1024_147 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_148 (out_1024 vdd norout1024_148 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_149 (out_1024 vdd norout1024_149 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_150 (out_1024 vdd norout1024_150 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_151 (out_1024 vdd norout1024_151 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_152 (out_1024 vdd norout1024_152 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_153 (out_1024 vdd norout1024_153 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_154 (out_1024 vdd norout1024_154 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_155 (out_1024 vdd norout1024_155 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_156 (out_1024 vdd norout1024_156 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_157 (out_1024 vdd norout1024_157 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_158 (out_1024 vdd norout1024_158 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_159 (out_1024 vdd norout1024_159 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_160 (out_1024 vdd norout1024_160 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_161 (out_1024 vdd norout1024_161 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_162 (out_1024 vdd norout1024_162 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_163 (out_1024 vdd norout1024_163 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_164 (out_1024 vdd norout1024_164 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_165 (out_1024 vdd norout1024_165 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_166 (out_1024 vdd norout1024_166 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_167 (out_1024 vdd norout1024_167 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_168 (out_1024 vdd norout1024_168 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_169 (out_1024 vdd norout1024_169 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_170 (out_1024 vdd norout1024_170 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_171 (out_1024 vdd norout1024_171 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_172 (out_1024 vdd norout1024_172 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_173 (out_1024 vdd norout1024_173 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_174 (out_1024 vdd norout1024_174 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_175 (out_1024 vdd norout1024_175 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_176 (out_1024 vdd norout1024_176 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_177 (out_1024 vdd norout1024_177 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_178 (out_1024 vdd norout1024_178 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_179 (out_1024 vdd norout1024_179 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_180 (out_1024 vdd norout1024_180 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_181 (out_1024 vdd norout1024_181 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_182 (out_1024 vdd norout1024_182 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_183 (out_1024 vdd norout1024_183 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_184 (out_1024 vdd norout1024_184 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_185 (out_1024 vdd norout1024_185 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_186 (out_1024 vdd norout1024_186 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_187 (out_1024 vdd norout1024_187 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_188 (out_1024 vdd norout1024_188 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_189 (out_1024 vdd norout1024_189 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_190 (out_1024 vdd norout1024_190 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_191 (out_1024 vdd norout1024_191 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_192 (out_1024 vdd norout1024_192 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_193 (out_1024 vdd norout1024_193 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_194 (out_1024 vdd norout1024_194 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_195 (out_1024 vdd norout1024_195 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_196 (out_1024 vdd norout1024_196 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_197 (out_1024 vdd norout1024_197 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_198 (out_1024 vdd norout1024_198 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_199 (out_1024 vdd norout1024_199 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_200 (out_1024 vdd norout1024_200 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_201 (out_1024 vdd norout1024_201 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_202 (out_1024 vdd norout1024_202 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_203 (out_1024 vdd norout1024_203 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_204 (out_1024 vdd norout1024_204 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_205 (out_1024 vdd norout1024_205 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_206 (out_1024 vdd norout1024_206 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_207 (out_1024 vdd norout1024_207 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_208 (out_1024 vdd norout1024_208 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_209 (out_1024 vdd norout1024_209 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_210 (out_1024 vdd norout1024_210 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_211 (out_1024 vdd norout1024_211 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_212 (out_1024 vdd norout1024_212 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_213 (out_1024 vdd norout1024_213 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_214 (out_1024 vdd norout1024_214 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_215 (out_1024 vdd norout1024_215 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_216 (out_1024 vdd norout1024_216 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_217 (out_1024 vdd norout1024_217 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_218 (out_1024 vdd norout1024_218 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_219 (out_1024 vdd norout1024_219 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_220 (out_1024 vdd norout1024_220 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_221 (out_1024 vdd norout1024_221 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_222 (out_1024 vdd norout1024_222 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_223 (out_1024 vdd norout1024_223 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_224 (out_1024 vdd norout1024_224 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_225 (out_1024 vdd norout1024_225 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_226 (out_1024 vdd norout1024_226 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_227 (out_1024 vdd norout1024_227 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_228 (out_1024 vdd norout1024_228 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_229 (out_1024 vdd norout1024_229 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_230 (out_1024 vdd norout1024_230 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_231 (out_1024 vdd norout1024_231 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_232 (out_1024 vdd norout1024_232 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_233 (out_1024 vdd norout1024_233 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_234 (out_1024 vdd norout1024_234 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_235 (out_1024 vdd norout1024_235 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_236 (out_1024 vdd norout1024_236 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_237 (out_1024 vdd norout1024_237 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_238 (out_1024 vdd norout1024_238 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_239 (out_1024 vdd norout1024_239 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_240 (out_1024 vdd norout1024_240 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_241 (out_1024 vdd norout1024_241 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_242 (out_1024 vdd norout1024_242 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_243 (out_1024 vdd norout1024_243 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_244 (out_1024 vdd norout1024_244 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_245 (out_1024 vdd norout1024_245 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_246 (out_1024 vdd norout1024_246 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_247 (out_1024 vdd norout1024_247 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_248 (out_1024 vdd norout1024_248 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_249 (out_1024 vdd norout1024_249 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_250 (out_1024 vdd norout1024_250 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_251 (out_1024 vdd norout1024_251 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_252 (out_1024 vdd norout1024_252 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_253 (out_1024 vdd norout1024_253 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_254 (out_1024 vdd norout1024_254 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_255 (out_1024 vdd norout1024_255 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_256 (out_1024 vdd norout1024_256 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_257 (out_1024 vdd norout1024_257 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_258 (out_1024 vdd norout1024_258 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_259 (out_1024 vdd norout1024_259 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_260 (out_1024 vdd norout1024_260 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_261 (out_1024 vdd norout1024_261 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_262 (out_1024 vdd norout1024_262 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_263 (out_1024 vdd norout1024_263 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_264 (out_1024 vdd norout1024_264 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_265 (out_1024 vdd norout1024_265 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_266 (out_1024 vdd norout1024_266 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_267 (out_1024 vdd norout1024_267 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_268 (out_1024 vdd norout1024_268 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_269 (out_1024 vdd norout1024_269 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_270 (out_1024 vdd norout1024_270 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_271 (out_1024 vdd norout1024_271 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_272 (out_1024 vdd norout1024_272 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_273 (out_1024 vdd norout1024_273 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_274 (out_1024 vdd norout1024_274 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_275 (out_1024 vdd norout1024_275 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_276 (out_1024 vdd norout1024_276 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_277 (out_1024 vdd norout1024_277 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_278 (out_1024 vdd norout1024_278 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_279 (out_1024 vdd norout1024_279 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_280 (out_1024 vdd norout1024_280 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_281 (out_1024 vdd norout1024_281 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_282 (out_1024 vdd norout1024_282 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_283 (out_1024 vdd norout1024_283 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_284 (out_1024 vdd norout1024_284 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_285 (out_1024 vdd norout1024_285 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_286 (out_1024 vdd norout1024_286 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_287 (out_1024 vdd norout1024_287 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_288 (out_1024 vdd norout1024_288 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_289 (out_1024 vdd norout1024_289 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_290 (out_1024 vdd norout1024_290 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_291 (out_1024 vdd norout1024_291 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_292 (out_1024 vdd norout1024_292 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_293 (out_1024 vdd norout1024_293 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_294 (out_1024 vdd norout1024_294 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_295 (out_1024 vdd norout1024_295 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_296 (out_1024 vdd norout1024_296 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_297 (out_1024 vdd norout1024_297 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_298 (out_1024 vdd norout1024_298 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_299 (out_1024 vdd norout1024_299 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_300 (out_1024 vdd norout1024_300 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_301 (out_1024 vdd norout1024_301 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_302 (out_1024 vdd norout1024_302 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_303 (out_1024 vdd norout1024_303 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_304 (out_1024 vdd norout1024_304 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_305 (out_1024 vdd norout1024_305 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_306 (out_1024 vdd norout1024_306 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_307 (out_1024 vdd norout1024_307 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_308 (out_1024 vdd norout1024_308 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_309 (out_1024 vdd norout1024_309 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_310 (out_1024 vdd norout1024_310 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_311 (out_1024 vdd norout1024_311 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_312 (out_1024 vdd norout1024_312 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_313 (out_1024 vdd norout1024_313 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_314 (out_1024 vdd norout1024_314 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_315 (out_1024 vdd norout1024_315 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_316 (out_1024 vdd norout1024_316 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_317 (out_1024 vdd norout1024_317 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_318 (out_1024 vdd norout1024_318 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_319 (out_1024 vdd norout1024_319 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_320 (out_1024 vdd norout1024_320 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_321 (out_1024 vdd norout1024_321 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_322 (out_1024 vdd norout1024_322 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_323 (out_1024 vdd norout1024_323 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_324 (out_1024 vdd norout1024_324 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_325 (out_1024 vdd norout1024_325 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_326 (out_1024 vdd norout1024_326 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_327 (out_1024 vdd norout1024_327 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_328 (out_1024 vdd norout1024_328 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_329 (out_1024 vdd norout1024_329 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_330 (out_1024 vdd norout1024_330 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_331 (out_1024 vdd norout1024_331 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_332 (out_1024 vdd norout1024_332 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_333 (out_1024 vdd norout1024_333 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_334 (out_1024 vdd norout1024_334 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_335 (out_1024 vdd norout1024_335 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_336 (out_1024 vdd norout1024_336 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_337 (out_1024 vdd norout1024_337 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_338 (out_1024 vdd norout1024_338 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_339 (out_1024 vdd norout1024_339 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_340 (out_1024 vdd norout1024_340 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_341 (out_1024 vdd norout1024_341 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_342 (out_1024 vdd norout1024_342 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_343 (out_1024 vdd norout1024_343 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_344 (out_1024 vdd norout1024_344 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_345 (out_1024 vdd norout1024_345 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_346 (out_1024 vdd norout1024_346 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_347 (out_1024 vdd norout1024_347 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_348 (out_1024 vdd norout1024_348 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_349 (out_1024 vdd norout1024_349 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_350 (out_1024 vdd norout1024_350 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_351 (out_1024 vdd norout1024_351 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_352 (out_1024 vdd norout1024_352 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_353 (out_1024 vdd norout1024_353 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_354 (out_1024 vdd norout1024_354 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_355 (out_1024 vdd norout1024_355 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_356 (out_1024 vdd norout1024_356 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_357 (out_1024 vdd norout1024_357 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_358 (out_1024 vdd norout1024_358 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_359 (out_1024 vdd norout1024_359 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_360 (out_1024 vdd norout1024_360 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_361 (out_1024 vdd norout1024_361 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_362 (out_1024 vdd norout1024_362 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_363 (out_1024 vdd norout1024_363 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_364 (out_1024 vdd norout1024_364 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_365 (out_1024 vdd norout1024_365 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_366 (out_1024 vdd norout1024_366 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_367 (out_1024 vdd norout1024_367 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_368 (out_1024 vdd norout1024_368 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_369 (out_1024 vdd norout1024_369 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_370 (out_1024 vdd norout1024_370 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_371 (out_1024 vdd norout1024_371 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_372 (out_1024 vdd norout1024_372 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_373 (out_1024 vdd norout1024_373 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_374 (out_1024 vdd norout1024_374 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_375 (out_1024 vdd norout1024_375 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_376 (out_1024 vdd norout1024_376 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_377 (out_1024 vdd norout1024_377 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_378 (out_1024 vdd norout1024_378 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_379 (out_1024 vdd norout1024_379 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_380 (out_1024 vdd norout1024_380 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_381 (out_1024 vdd norout1024_381 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_382 (out_1024 vdd norout1024_382 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_383 (out_1024 vdd norout1024_383 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_384 (out_1024 vdd norout1024_384 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_385 (out_1024 vdd norout1024_385 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_386 (out_1024 vdd norout1024_386 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_387 (out_1024 vdd norout1024_387 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_388 (out_1024 vdd norout1024_388 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_389 (out_1024 vdd norout1024_389 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_390 (out_1024 vdd norout1024_390 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_391 (out_1024 vdd norout1024_391 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_392 (out_1024 vdd norout1024_392 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_393 (out_1024 vdd norout1024_393 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_394 (out_1024 vdd norout1024_394 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_395 (out_1024 vdd norout1024_395 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_396 (out_1024 vdd norout1024_396 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_397 (out_1024 vdd norout1024_397 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_398 (out_1024 vdd norout1024_398 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_399 (out_1024 vdd norout1024_399 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_400 (out_1024 vdd norout1024_400 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_401 (out_1024 vdd norout1024_401 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_402 (out_1024 vdd norout1024_402 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_403 (out_1024 vdd norout1024_403 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_404 (out_1024 vdd norout1024_404 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_405 (out_1024 vdd norout1024_405 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_406 (out_1024 vdd norout1024_406 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_407 (out_1024 vdd norout1024_407 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_408 (out_1024 vdd norout1024_408 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_409 (out_1024 vdd norout1024_409 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_410 (out_1024 vdd norout1024_410 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_411 (out_1024 vdd norout1024_411 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_412 (out_1024 vdd norout1024_412 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_413 (out_1024 vdd norout1024_413 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_414 (out_1024 vdd norout1024_414 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_415 (out_1024 vdd norout1024_415 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_416 (out_1024 vdd norout1024_416 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_417 (out_1024 vdd norout1024_417 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_418 (out_1024 vdd norout1024_418 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_419 (out_1024 vdd norout1024_419 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_420 (out_1024 vdd norout1024_420 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_421 (out_1024 vdd norout1024_421 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_422 (out_1024 vdd norout1024_422 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_423 (out_1024 vdd norout1024_423 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_424 (out_1024 vdd norout1024_424 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_425 (out_1024 vdd norout1024_425 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_426 (out_1024 vdd norout1024_426 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_427 (out_1024 vdd norout1024_427 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_428 (out_1024 vdd norout1024_428 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_429 (out_1024 vdd norout1024_429 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_430 (out_1024 vdd norout1024_430 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_431 (out_1024 vdd norout1024_431 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_432 (out_1024 vdd norout1024_432 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_433 (out_1024 vdd norout1024_433 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_434 (out_1024 vdd norout1024_434 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_435 (out_1024 vdd norout1024_435 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_436 (out_1024 vdd norout1024_436 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_437 (out_1024 vdd norout1024_437 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_438 (out_1024 vdd norout1024_438 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_439 (out_1024 vdd norout1024_439 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_440 (out_1024 vdd norout1024_440 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_441 (out_1024 vdd norout1024_441 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_442 (out_1024 vdd norout1024_442 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_443 (out_1024 vdd norout1024_443 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_444 (out_1024 vdd norout1024_444 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_445 (out_1024 vdd norout1024_445 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_446 (out_1024 vdd norout1024_446 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_447 (out_1024 vdd norout1024_447 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_448 (out_1024 vdd norout1024_448 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_449 (out_1024 vdd norout1024_449 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_450 (out_1024 vdd norout1024_450 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_451 (out_1024 vdd norout1024_451 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_452 (out_1024 vdd norout1024_452 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_453 (out_1024 vdd norout1024_453 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_454 (out_1024 vdd norout1024_454 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_455 (out_1024 vdd norout1024_455 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_456 (out_1024 vdd norout1024_456 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_457 (out_1024 vdd norout1024_457 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_458 (out_1024 vdd norout1024_458 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_459 (out_1024 vdd norout1024_459 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_460 (out_1024 vdd norout1024_460 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_461 (out_1024 vdd norout1024_461 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_462 (out_1024 vdd norout1024_462 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_463 (out_1024 vdd norout1024_463 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_464 (out_1024 vdd norout1024_464 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_465 (out_1024 vdd norout1024_465 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_466 (out_1024 vdd norout1024_466 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_467 (out_1024 vdd norout1024_467 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_468 (out_1024 vdd norout1024_468 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_469 (out_1024 vdd norout1024_469 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_470 (out_1024 vdd norout1024_470 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_471 (out_1024 vdd norout1024_471 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_472 (out_1024 vdd norout1024_472 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_473 (out_1024 vdd norout1024_473 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_474 (out_1024 vdd norout1024_474 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_475 (out_1024 vdd norout1024_475 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_476 (out_1024 vdd norout1024_476 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_477 (out_1024 vdd norout1024_477 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_478 (out_1024 vdd norout1024_478 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_479 (out_1024 vdd norout1024_479 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_480 (out_1024 vdd norout1024_480 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_481 (out_1024 vdd norout1024_481 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_482 (out_1024 vdd norout1024_482 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_483 (out_1024 vdd norout1024_483 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_484 (out_1024 vdd norout1024_484 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_485 (out_1024 vdd norout1024_485 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_486 (out_1024 vdd norout1024_486 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_487 (out_1024 vdd norout1024_487 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_488 (out_1024 vdd norout1024_488 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_489 (out_1024 vdd norout1024_489 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_490 (out_1024 vdd norout1024_490 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_491 (out_1024 vdd norout1024_491 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_492 (out_1024 vdd norout1024_492 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_493 (out_1024 vdd norout1024_493 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_494 (out_1024 vdd norout1024_494 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_495 (out_1024 vdd norout1024_495 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_496 (out_1024 vdd norout1024_496 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_497 (out_1024 vdd norout1024_497 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_498 (out_1024 vdd norout1024_498 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_499 (out_1024 vdd norout1024_499 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_500 (out_1024 vdd norout1024_500 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_501 (out_1024 vdd norout1024_501 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_502 (out_1024 vdd norout1024_502 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_503 (out_1024 vdd norout1024_503 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_504 (out_1024 vdd norout1024_504 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_505 (out_1024 vdd norout1024_505 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_506 (out_1024 vdd norout1024_506 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_507 (out_1024 vdd norout1024_507 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_508 (out_1024 vdd norout1024_508 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_509 (out_1024 vdd norout1024_509 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_510 (out_1024 vdd norout1024_510 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_511 (out_1024 vdd norout1024_511 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_512 (out_1024 vdd norout1024_512 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_513 (out_1024 vdd norout1024_513 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_514 (out_1024 vdd norout1024_514 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_515 (out_1024 vdd norout1024_515 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_516 (out_1024 vdd norout1024_516 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_517 (out_1024 vdd norout1024_517 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_518 (out_1024 vdd norout1024_518 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_519 (out_1024 vdd norout1024_519 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_520 (out_1024 vdd norout1024_520 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_521 (out_1024 vdd norout1024_521 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_522 (out_1024 vdd norout1024_522 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_523 (out_1024 vdd norout1024_523 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_524 (out_1024 vdd norout1024_524 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_525 (out_1024 vdd norout1024_525 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_526 (out_1024 vdd norout1024_526 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_527 (out_1024 vdd norout1024_527 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_528 (out_1024 vdd norout1024_528 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_529 (out_1024 vdd norout1024_529 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_530 (out_1024 vdd norout1024_530 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_531 (out_1024 vdd norout1024_531 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_532 (out_1024 vdd norout1024_532 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_533 (out_1024 vdd norout1024_533 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_534 (out_1024 vdd norout1024_534 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_535 (out_1024 vdd norout1024_535 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_536 (out_1024 vdd norout1024_536 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_537 (out_1024 vdd norout1024_537 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_538 (out_1024 vdd norout1024_538 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_539 (out_1024 vdd norout1024_539 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_540 (out_1024 vdd norout1024_540 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_541 (out_1024 vdd norout1024_541 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_542 (out_1024 vdd norout1024_542 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_543 (out_1024 vdd norout1024_543 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_544 (out_1024 vdd norout1024_544 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_545 (out_1024 vdd norout1024_545 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_546 (out_1024 vdd norout1024_546 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_547 (out_1024 vdd norout1024_547 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_548 (out_1024 vdd norout1024_548 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_549 (out_1024 vdd norout1024_549 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_550 (out_1024 vdd norout1024_550 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_551 (out_1024 vdd norout1024_551 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_552 (out_1024 vdd norout1024_552 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_553 (out_1024 vdd norout1024_553 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_554 (out_1024 vdd norout1024_554 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_555 (out_1024 vdd norout1024_555 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_556 (out_1024 vdd norout1024_556 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_557 (out_1024 vdd norout1024_557 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_558 (out_1024 vdd norout1024_558 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_559 (out_1024 vdd norout1024_559 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_560 (out_1024 vdd norout1024_560 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_561 (out_1024 vdd norout1024_561 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_562 (out_1024 vdd norout1024_562 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_563 (out_1024 vdd norout1024_563 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_564 (out_1024 vdd norout1024_564 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_565 (out_1024 vdd norout1024_565 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_566 (out_1024 vdd norout1024_566 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_567 (out_1024 vdd norout1024_567 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_568 (out_1024 vdd norout1024_568 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_569 (out_1024 vdd norout1024_569 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_570 (out_1024 vdd norout1024_570 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_571 (out_1024 vdd norout1024_571 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_572 (out_1024 vdd norout1024_572 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_573 (out_1024 vdd norout1024_573 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_574 (out_1024 vdd norout1024_574 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_575 (out_1024 vdd norout1024_575 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_576 (out_1024 vdd norout1024_576 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_577 (out_1024 vdd norout1024_577 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_578 (out_1024 vdd norout1024_578 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_579 (out_1024 vdd norout1024_579 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_580 (out_1024 vdd norout1024_580 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_581 (out_1024 vdd norout1024_581 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_582 (out_1024 vdd norout1024_582 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_583 (out_1024 vdd norout1024_583 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_584 (out_1024 vdd norout1024_584 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_585 (out_1024 vdd norout1024_585 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_586 (out_1024 vdd norout1024_586 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_587 (out_1024 vdd norout1024_587 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_588 (out_1024 vdd norout1024_588 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_589 (out_1024 vdd norout1024_589 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_590 (out_1024 vdd norout1024_590 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_591 (out_1024 vdd norout1024_591 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_592 (out_1024 vdd norout1024_592 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_593 (out_1024 vdd norout1024_593 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_594 (out_1024 vdd norout1024_594 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_595 (out_1024 vdd norout1024_595 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_596 (out_1024 vdd norout1024_596 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_597 (out_1024 vdd norout1024_597 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_598 (out_1024 vdd norout1024_598 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_599 (out_1024 vdd norout1024_599 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_600 (out_1024 vdd norout1024_600 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_601 (out_1024 vdd norout1024_601 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_602 (out_1024 vdd norout1024_602 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_603 (out_1024 vdd norout1024_603 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_604 (out_1024 vdd norout1024_604 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_605 (out_1024 vdd norout1024_605 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_606 (out_1024 vdd norout1024_606 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_607 (out_1024 vdd norout1024_607 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_608 (out_1024 vdd norout1024_608 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_609 (out_1024 vdd norout1024_609 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_610 (out_1024 vdd norout1024_610 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_611 (out_1024 vdd norout1024_611 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_612 (out_1024 vdd norout1024_612 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_613 (out_1024 vdd norout1024_613 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_614 (out_1024 vdd norout1024_614 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_615 (out_1024 vdd norout1024_615 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_616 (out_1024 vdd norout1024_616 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_617 (out_1024 vdd norout1024_617 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_618 (out_1024 vdd norout1024_618 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_619 (out_1024 vdd norout1024_619 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_620 (out_1024 vdd norout1024_620 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_621 (out_1024 vdd norout1024_621 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_622 (out_1024 vdd norout1024_622 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_623 (out_1024 vdd norout1024_623 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_624 (out_1024 vdd norout1024_624 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_625 (out_1024 vdd norout1024_625 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_626 (out_1024 vdd norout1024_626 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_627 (out_1024 vdd norout1024_627 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_628 (out_1024 vdd norout1024_628 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_629 (out_1024 vdd norout1024_629 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_630 (out_1024 vdd norout1024_630 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_631 (out_1024 vdd norout1024_631 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_632 (out_1024 vdd norout1024_632 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_633 (out_1024 vdd norout1024_633 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_634 (out_1024 vdd norout1024_634 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_635 (out_1024 vdd norout1024_635 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_636 (out_1024 vdd norout1024_636 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_637 (out_1024 vdd norout1024_637 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_638 (out_1024 vdd norout1024_638 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_639 (out_1024 vdd norout1024_639 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_640 (out_1024 vdd norout1024_640 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_641 (out_1024 vdd norout1024_641 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_642 (out_1024 vdd norout1024_642 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_643 (out_1024 vdd norout1024_643 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_644 (out_1024 vdd norout1024_644 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_645 (out_1024 vdd norout1024_645 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_646 (out_1024 vdd norout1024_646 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_647 (out_1024 vdd norout1024_647 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_648 (out_1024 vdd norout1024_648 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_649 (out_1024 vdd norout1024_649 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_650 (out_1024 vdd norout1024_650 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_651 (out_1024 vdd norout1024_651 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_652 (out_1024 vdd norout1024_652 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_653 (out_1024 vdd norout1024_653 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_654 (out_1024 vdd norout1024_654 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_655 (out_1024 vdd norout1024_655 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_656 (out_1024 vdd norout1024_656 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_657 (out_1024 vdd norout1024_657 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_658 (out_1024 vdd norout1024_658 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_659 (out_1024 vdd norout1024_659 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_660 (out_1024 vdd norout1024_660 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_661 (out_1024 vdd norout1024_661 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_662 (out_1024 vdd norout1024_662 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_663 (out_1024 vdd norout1024_663 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_664 (out_1024 vdd norout1024_664 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_665 (out_1024 vdd norout1024_665 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_666 (out_1024 vdd norout1024_666 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_667 (out_1024 vdd norout1024_667 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_668 (out_1024 vdd norout1024_668 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_669 (out_1024 vdd norout1024_669 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_670 (out_1024 vdd norout1024_670 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_671 (out_1024 vdd norout1024_671 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_672 (out_1024 vdd norout1024_672 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_673 (out_1024 vdd norout1024_673 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_674 (out_1024 vdd norout1024_674 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_675 (out_1024 vdd norout1024_675 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_676 (out_1024 vdd norout1024_676 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_677 (out_1024 vdd norout1024_677 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_678 (out_1024 vdd norout1024_678 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_679 (out_1024 vdd norout1024_679 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_680 (out_1024 vdd norout1024_680 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_681 (out_1024 vdd norout1024_681 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_682 (out_1024 vdd norout1024_682 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_683 (out_1024 vdd norout1024_683 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_684 (out_1024 vdd norout1024_684 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_685 (out_1024 vdd norout1024_685 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_686 (out_1024 vdd norout1024_686 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_687 (out_1024 vdd norout1024_687 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_688 (out_1024 vdd norout1024_688 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_689 (out_1024 vdd norout1024_689 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_690 (out_1024 vdd norout1024_690 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_691 (out_1024 vdd norout1024_691 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_692 (out_1024 vdd norout1024_692 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_693 (out_1024 vdd norout1024_693 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_694 (out_1024 vdd norout1024_694 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_695 (out_1024 vdd norout1024_695 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_696 (out_1024 vdd norout1024_696 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_697 (out_1024 vdd norout1024_697 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_698 (out_1024 vdd norout1024_698 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_699 (out_1024 vdd norout1024_699 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_700 (out_1024 vdd norout1024_700 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_701 (out_1024 vdd norout1024_701 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_702 (out_1024 vdd norout1024_702 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_703 (out_1024 vdd norout1024_703 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_704 (out_1024 vdd norout1024_704 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_705 (out_1024 vdd norout1024_705 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_706 (out_1024 vdd norout1024_706 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_707 (out_1024 vdd norout1024_707 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_708 (out_1024 vdd norout1024_708 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_709 (out_1024 vdd norout1024_709 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_710 (out_1024 vdd norout1024_710 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_711 (out_1024 vdd norout1024_711 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_712 (out_1024 vdd norout1024_712 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_713 (out_1024 vdd norout1024_713 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_714 (out_1024 vdd norout1024_714 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_715 (out_1024 vdd norout1024_715 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_716 (out_1024 vdd norout1024_716 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_717 (out_1024 vdd norout1024_717 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_718 (out_1024 vdd norout1024_718 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_719 (out_1024 vdd norout1024_719 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_720 (out_1024 vdd norout1024_720 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_721 (out_1024 vdd norout1024_721 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_722 (out_1024 vdd norout1024_722 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_723 (out_1024 vdd norout1024_723 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_724 (out_1024 vdd norout1024_724 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_725 (out_1024 vdd norout1024_725 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_726 (out_1024 vdd norout1024_726 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_727 (out_1024 vdd norout1024_727 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_728 (out_1024 vdd norout1024_728 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_729 (out_1024 vdd norout1024_729 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_730 (out_1024 vdd norout1024_730 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_731 (out_1024 vdd norout1024_731 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_732 (out_1024 vdd norout1024_732 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_733 (out_1024 vdd norout1024_733 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_734 (out_1024 vdd norout1024_734 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_735 (out_1024 vdd norout1024_735 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_736 (out_1024 vdd norout1024_736 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_737 (out_1024 vdd norout1024_737 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_738 (out_1024 vdd norout1024_738 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_739 (out_1024 vdd norout1024_739 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_740 (out_1024 vdd norout1024_740 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_741 (out_1024 vdd norout1024_741 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_742 (out_1024 vdd norout1024_742 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_743 (out_1024 vdd norout1024_743 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_744 (out_1024 vdd norout1024_744 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_745 (out_1024 vdd norout1024_745 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_746 (out_1024 vdd norout1024_746 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_747 (out_1024 vdd norout1024_747 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_748 (out_1024 vdd norout1024_748 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_749 (out_1024 vdd norout1024_749 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_750 (out_1024 vdd norout1024_750 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_751 (out_1024 vdd norout1024_751 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_752 (out_1024 vdd norout1024_752 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_753 (out_1024 vdd norout1024_753 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_754 (out_1024 vdd norout1024_754 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_755 (out_1024 vdd norout1024_755 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_756 (out_1024 vdd norout1024_756 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_757 (out_1024 vdd norout1024_757 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_758 (out_1024 vdd norout1024_758 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_759 (out_1024 vdd norout1024_759 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_760 (out_1024 vdd norout1024_760 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_761 (out_1024 vdd norout1024_761 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_762 (out_1024 vdd norout1024_762 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_763 (out_1024 vdd norout1024_763 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_764 (out_1024 vdd norout1024_764 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_765 (out_1024 vdd norout1024_765 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_766 (out_1024 vdd norout1024_766 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_767 (out_1024 vdd norout1024_767 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_768 (out_1024 vdd norout1024_768 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_769 (out_1024 vdd norout1024_769 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_770 (out_1024 vdd norout1024_770 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_771 (out_1024 vdd norout1024_771 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_772 (out_1024 vdd norout1024_772 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_773 (out_1024 vdd norout1024_773 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_774 (out_1024 vdd norout1024_774 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_775 (out_1024 vdd norout1024_775 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_776 (out_1024 vdd norout1024_776 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_777 (out_1024 vdd norout1024_777 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_778 (out_1024 vdd norout1024_778 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_779 (out_1024 vdd norout1024_779 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_780 (out_1024 vdd norout1024_780 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_781 (out_1024 vdd norout1024_781 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_782 (out_1024 vdd norout1024_782 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_783 (out_1024 vdd norout1024_783 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_784 (out_1024 vdd norout1024_784 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_785 (out_1024 vdd norout1024_785 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_786 (out_1024 vdd norout1024_786 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_787 (out_1024 vdd norout1024_787 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_788 (out_1024 vdd norout1024_788 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_789 (out_1024 vdd norout1024_789 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_790 (out_1024 vdd norout1024_790 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_791 (out_1024 vdd norout1024_791 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_792 (out_1024 vdd norout1024_792 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_793 (out_1024 vdd norout1024_793 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_794 (out_1024 vdd norout1024_794 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_795 (out_1024 vdd norout1024_795 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_796 (out_1024 vdd norout1024_796 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_797 (out_1024 vdd norout1024_797 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_798 (out_1024 vdd norout1024_798 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_799 (out_1024 vdd norout1024_799 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_800 (out_1024 vdd norout1024_800 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_801 (out_1024 vdd norout1024_801 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_802 (out_1024 vdd norout1024_802 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_803 (out_1024 vdd norout1024_803 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_804 (out_1024 vdd norout1024_804 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_805 (out_1024 vdd norout1024_805 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_806 (out_1024 vdd norout1024_806 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_807 (out_1024 vdd norout1024_807 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_808 (out_1024 vdd norout1024_808 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_809 (out_1024 vdd norout1024_809 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_810 (out_1024 vdd norout1024_810 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_811 (out_1024 vdd norout1024_811 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_812 (out_1024 vdd norout1024_812 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_813 (out_1024 vdd norout1024_813 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_814 (out_1024 vdd norout1024_814 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_815 (out_1024 vdd norout1024_815 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_816 (out_1024 vdd norout1024_816 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_817 (out_1024 vdd norout1024_817 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_818 (out_1024 vdd norout1024_818 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_819 (out_1024 vdd norout1024_819 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_820 (out_1024 vdd norout1024_820 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_821 (out_1024 vdd norout1024_821 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_822 (out_1024 vdd norout1024_822 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_823 (out_1024 vdd norout1024_823 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_824 (out_1024 vdd norout1024_824 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_825 (out_1024 vdd norout1024_825 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_826 (out_1024 vdd norout1024_826 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_827 (out_1024 vdd norout1024_827 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_828 (out_1024 vdd norout1024_828 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_829 (out_1024 vdd norout1024_829 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_830 (out_1024 vdd norout1024_830 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_831 (out_1024 vdd norout1024_831 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_832 (out_1024 vdd norout1024_832 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_833 (out_1024 vdd norout1024_833 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_834 (out_1024 vdd norout1024_834 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_835 (out_1024 vdd norout1024_835 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_836 (out_1024 vdd norout1024_836 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_837 (out_1024 vdd norout1024_837 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_838 (out_1024 vdd norout1024_838 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_839 (out_1024 vdd norout1024_839 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_840 (out_1024 vdd norout1024_840 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_841 (out_1024 vdd norout1024_841 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_842 (out_1024 vdd norout1024_842 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_843 (out_1024 vdd norout1024_843 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_844 (out_1024 vdd norout1024_844 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_845 (out_1024 vdd norout1024_845 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_846 (out_1024 vdd norout1024_846 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_847 (out_1024 vdd norout1024_847 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_848 (out_1024 vdd norout1024_848 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_849 (out_1024 vdd norout1024_849 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_850 (out_1024 vdd norout1024_850 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_851 (out_1024 vdd norout1024_851 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_852 (out_1024 vdd norout1024_852 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_853 (out_1024 vdd norout1024_853 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_854 (out_1024 vdd norout1024_854 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_855 (out_1024 vdd norout1024_855 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_856 (out_1024 vdd norout1024_856 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_857 (out_1024 vdd norout1024_857 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_858 (out_1024 vdd norout1024_858 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_859 (out_1024 vdd norout1024_859 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_860 (out_1024 vdd norout1024_860 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_861 (out_1024 vdd norout1024_861 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_862 (out_1024 vdd norout1024_862 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_863 (out_1024 vdd norout1024_863 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_864 (out_1024 vdd norout1024_864 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_865 (out_1024 vdd norout1024_865 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_866 (out_1024 vdd norout1024_866 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_867 (out_1024 vdd norout1024_867 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_868 (out_1024 vdd norout1024_868 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_869 (out_1024 vdd norout1024_869 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_870 (out_1024 vdd norout1024_870 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_871 (out_1024 vdd norout1024_871 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_872 (out_1024 vdd norout1024_872 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_873 (out_1024 vdd norout1024_873 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_874 (out_1024 vdd norout1024_874 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_875 (out_1024 vdd norout1024_875 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_876 (out_1024 vdd norout1024_876 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_877 (out_1024 vdd norout1024_877 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_878 (out_1024 vdd norout1024_878 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_879 (out_1024 vdd norout1024_879 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_880 (out_1024 vdd norout1024_880 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_881 (out_1024 vdd norout1024_881 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_882 (out_1024 vdd norout1024_882 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_883 (out_1024 vdd norout1024_883 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_884 (out_1024 vdd norout1024_884 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_885 (out_1024 vdd norout1024_885 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_886 (out_1024 vdd norout1024_886 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_887 (out_1024 vdd norout1024_887 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_888 (out_1024 vdd norout1024_888 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_889 (out_1024 vdd norout1024_889 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_890 (out_1024 vdd norout1024_890 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_891 (out_1024 vdd norout1024_891 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_892 (out_1024 vdd norout1024_892 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_893 (out_1024 vdd norout1024_893 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_894 (out_1024 vdd norout1024_894 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_895 (out_1024 vdd norout1024_895 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_896 (out_1024 vdd norout1024_896 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_897 (out_1024 vdd norout1024_897 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_898 (out_1024 vdd norout1024_898 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_899 (out_1024 vdd norout1024_899 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_900 (out_1024 vdd norout1024_900 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_901 (out_1024 vdd norout1024_901 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_902 (out_1024 vdd norout1024_902 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_903 (out_1024 vdd norout1024_903 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_904 (out_1024 vdd norout1024_904 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_905 (out_1024 vdd norout1024_905 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_906 (out_1024 vdd norout1024_906 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_907 (out_1024 vdd norout1024_907 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_908 (out_1024 vdd norout1024_908 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_909 (out_1024 vdd norout1024_909 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_910 (out_1024 vdd norout1024_910 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_911 (out_1024 vdd norout1024_911 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_912 (out_1024 vdd norout1024_912 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_913 (out_1024 vdd norout1024_913 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_914 (out_1024 vdd norout1024_914 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_915 (out_1024 vdd norout1024_915 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_916 (out_1024 vdd norout1024_916 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_917 (out_1024 vdd norout1024_917 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_918 (out_1024 vdd norout1024_918 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_919 (out_1024 vdd norout1024_919 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_920 (out_1024 vdd norout1024_920 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_921 (out_1024 vdd norout1024_921 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_922 (out_1024 vdd norout1024_922 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_923 (out_1024 vdd norout1024_923 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_924 (out_1024 vdd norout1024_924 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_925 (out_1024 vdd norout1024_925 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_926 (out_1024 vdd norout1024_926 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_927 (out_1024 vdd norout1024_927 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_928 (out_1024 vdd norout1024_928 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_929 (out_1024 vdd norout1024_929 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_930 (out_1024 vdd norout1024_930 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_931 (out_1024 vdd norout1024_931 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_932 (out_1024 vdd norout1024_932 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_933 (out_1024 vdd norout1024_933 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_934 (out_1024 vdd norout1024_934 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_935 (out_1024 vdd norout1024_935 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_936 (out_1024 vdd norout1024_936 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_937 (out_1024 vdd norout1024_937 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_938 (out_1024 vdd norout1024_938 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_939 (out_1024 vdd norout1024_939 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_940 (out_1024 vdd norout1024_940 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_941 (out_1024 vdd norout1024_941 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_942 (out_1024 vdd norout1024_942 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_943 (out_1024 vdd norout1024_943 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_944 (out_1024 vdd norout1024_944 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_945 (out_1024 vdd norout1024_945 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_946 (out_1024 vdd norout1024_946 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_947 (out_1024 vdd norout1024_947 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_948 (out_1024 vdd norout1024_948 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_949 (out_1024 vdd norout1024_949 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_950 (out_1024 vdd norout1024_950 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_951 (out_1024 vdd norout1024_951 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_952 (out_1024 vdd norout1024_952 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_953 (out_1024 vdd norout1024_953 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_954 (out_1024 vdd norout1024_954 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_955 (out_1024 vdd norout1024_955 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_956 (out_1024 vdd norout1024_956 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_957 (out_1024 vdd norout1024_957 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_958 (out_1024 vdd norout1024_958 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_959 (out_1024 vdd norout1024_959 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_960 (out_1024 vdd norout1024_960 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_961 (out_1024 vdd norout1024_961 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_962 (out_1024 vdd norout1024_962 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_963 (out_1024 vdd norout1024_963 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_964 (out_1024 vdd norout1024_964 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_965 (out_1024 vdd norout1024_965 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_966 (out_1024 vdd norout1024_966 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_967 (out_1024 vdd norout1024_967 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_968 (out_1024 vdd norout1024_968 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_969 (out_1024 vdd norout1024_969 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_970 (out_1024 vdd norout1024_970 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_971 (out_1024 vdd norout1024_971 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_972 (out_1024 vdd norout1024_972 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_973 (out_1024 vdd norout1024_973 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_974 (out_1024 vdd norout1024_974 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_975 (out_1024 vdd norout1024_975 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_976 (out_1024 vdd norout1024_976 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_977 (out_1024 vdd norout1024_977 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_978 (out_1024 vdd norout1024_978 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_979 (out_1024 vdd norout1024_979 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_980 (out_1024 vdd norout1024_980 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_981 (out_1024 vdd norout1024_981 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_982 (out_1024 vdd norout1024_982 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_983 (out_1024 vdd norout1024_983 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_984 (out_1024 vdd norout1024_984 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_985 (out_1024 vdd norout1024_985 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_986 (out_1024 vdd norout1024_986 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_987 (out_1024 vdd norout1024_987 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_988 (out_1024 vdd norout1024_988 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_989 (out_1024 vdd norout1024_989 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_990 (out_1024 vdd norout1024_990 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_991 (out_1024 vdd norout1024_991 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_992 (out_1024 vdd norout1024_992 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_993 (out_1024 vdd norout1024_993 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_994 (out_1024 vdd norout1024_994 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_995 (out_1024 vdd norout1024_995 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_996 (out_1024 vdd norout1024_996 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_997 (out_1024 vdd norout1024_997 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_998 (out_1024 vdd norout1024_998 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_999 (out_1024 vdd norout1024_999 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1000 (out_1024 vdd norout1024_1000 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1001 (out_1024 vdd norout1024_1001 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1002 (out_1024 vdd norout1024_1002 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1003 (out_1024 vdd norout1024_1003 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1004 (out_1024 vdd norout1024_1004 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1005 (out_1024 vdd norout1024_1005 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1006 (out_1024 vdd norout1024_1006 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1007 (out_1024 vdd norout1024_1007 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1008 (out_1024 vdd norout1024_1008 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1009 (out_1024 vdd norout1024_1009 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1010 (out_1024 vdd norout1024_1010 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1011 (out_1024 vdd norout1024_1011 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1012 (out_1024 vdd norout1024_1012 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1013 (out_1024 vdd norout1024_1013 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1014 (out_1024 vdd norout1024_1014 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1015 (out_1024 vdd norout1024_1015 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1016 (out_1024 vdd norout1024_1016 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1017 (out_1024 vdd norout1024_1017 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1018 (out_1024 vdd norout1024_1018 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1019 (out_1024 vdd norout1024_1019 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1020 (out_1024 vdd norout1024_1020 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1021 (out_1024 vdd norout1024_1021 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1022 (out_1024 vdd norout1024_1022 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1023 (out_1024 vdd norout1024_1023 vdd vss PBulkLine NBulkLine) twonor
//nor_1024_1024 (out_1024 vdd norout1024_1024 vdd vss PBulkLine NBulkLine) twonor
cPar_1024 out_1024 vss capacitor c=1.8432e-13

ends buffer_notsized

xbuffer_sized (vdd vss vss vdd in out_buffered_8 out_buffered_16 out_buffered_32 out_buffered_64 out_buffered_128 out_buffered_256 out_buffered_512 out_buffered_1024) buffer_sized
xbuffer_notsized (vdd vss vss vdd in out_notbuffered_8 out_notbuffered_16 out_notbuffered_32 out_notbuffered_64 out_notbuffered_128 out_notbuffered_256 out_notbuffered_512 out_notbuffered_1024) buffer_notsized
save in
save out_buffered_8
save out_notbuffered_8
save out_buffered_16
save out_notbuffered_16
save out_buffered_32
save out_notbuffered_32
save out_buffered_64
save out_notbuffered_64
save out_buffered_128
save out_notbuffered_128
save out_buffered_256
save out_notbuffered_256
save out_buffered_512
save out_notbuffered_512
save out_buffered_1024
save out_notbuffered_1024
