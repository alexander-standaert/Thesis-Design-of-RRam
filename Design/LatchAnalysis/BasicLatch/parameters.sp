simulator lang=spectre

parameters PWp = 80*100n
parameters PWn = 80*100n
parameters PWpenable = 40*100n
parameters PWnenable = 40*100n

parameters lepwave=[0 1 5e-10 1 5.5e-10 0 5.5e-09 0]
parameters lenwave=[0 1 5e-10 1 6e-10 1 5.5e-09 1]

parameters initialout=0.3
parameters initialoutbar=0.32

parameters numberofruns = 200
