simulator lang=spectre

parameters PWp = 20*100n
parameters PWn = 20*100n
parameters PWpenable = 20*100n
parameters PWnenable = 20*100n

parameters lepwave=[0 1 5e-10 1 5.5e-10 0 5.5e-09 0]
parameters lenwave=[0 0 5e-10 0 6e-10 1 5.5e-09 1]

parameters initialout=0.05
parameters initialoutbar=0.4

parameters numberofruns = 250
