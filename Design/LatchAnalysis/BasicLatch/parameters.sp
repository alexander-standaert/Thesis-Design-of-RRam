simulator lang=spectre

parameters PWp = 1*100n
parameters PWn = 1*100n
parameters PWpenable = 1*100n
parameters PWnenable = 1*100n

parameters lepwave=[0 1 1e-09 1 1.1e-09 1 6e-09 1]
parameters lenwave=[0 0 1e-09 0 1.05e-09 0 6e-09 0]

parameters initialout=0.5
parameters initialoutbar=0.5

parameters numberofruns = 1
