simulator lang=spectre

parameters PWp = 10*100n
parameters PWn = 10*100n
parameters PWpenable = 10*100n
parameters PWnenable = 10*100n

parameters lepwave=[0 1 5e-10 1 5.5e-10 0 5.5e-09 0]
parameters lenwave=[0 1 5e-10 1 6e-10 1 5.5e-09 1]

parameters initialout=0.3
parameters initialoutbar=0.30001

parameters numberofruns = 1
