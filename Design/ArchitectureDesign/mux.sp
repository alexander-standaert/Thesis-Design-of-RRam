simulator lang=spectre

subckt mux (IN_0 IN_1 IN_2 IN_3 IN_4 IN_5 IN_6 IN_7 IN_8 IN_9 IN_10 IN_11 IN_12 IN_13 IN_14 IN_15 IN_16 IN_17 IN_18 IN_19 IN_20 IN_21 IN_22 IN_23 IN_24 IN_25 IN_26 IN_27 IN_28 IN_29 SEL_0 SEL_1 SEL_2 SEL_3 SEL_4 SEL_5 SEL_6 SEL_7 SEL_8 SEL_9 SEL_10 SEL_11 SEL_12 SEL_13 SEL_14 SEL_15 SEL_16 SEL_17 SEL_18 SEL_19 SEL_20 SEL_21 SEL_22 SEL_23 SEL_24 SEL_25 SEL_26 SEL_27 SEL_28 SEL_29 OUT NBulkLine)

xM0 IN_0 SEL_0 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM1 IN_1 SEL_1 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM2 IN_2 SEL_2 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM3 IN_3 SEL_3 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM4 IN_4 SEL_4 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM5 IN_5 SEL_5 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM6 IN_6 SEL_6 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM7 IN_7 SEL_7 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM8 IN_8 SEL_8 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM9 IN_9 SEL_9 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM10 IN_10 SEL_10 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM11 IN_11 SEL_11 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM12 IN_12 SEL_12 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM13 IN_13 SEL_13 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM14 IN_14 SEL_14 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM15 IN_15 SEL_15 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM16 IN_16 SEL_16 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM17 IN_17 SEL_17 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM18 IN_18 SEL_18 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM19 IN_19 SEL_19 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM20 IN_20 SEL_20 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM21 IN_21 SEL_21 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM22 IN_22 SEL_22 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM23 IN_23 SEL_23 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM24 IN_24 SEL_24 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM25 IN_25 SEL_25 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM26 IN_26 SEL_26 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM27 IN_27 SEL_27 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM28 IN_28 SEL_28 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin
xM29 IN_29 SEL_29 OUT NBulkLine mc_nmos_lvt w=PWmux l=PLmin

ends mux
