simulator lang=spice
.lib 'tech_wrapper.lib' tt

simulator lang=spectre

include "monte_carlo_models.scs"
include "globalblock.sp"
include "drivers.sp"
include "parameters.sp"
include "delay.sp"
include "CMOSlogic.scs"
include "buffers_INVNOR.sp"

xDrivers (vdd_0 vss NBulkLine PBulkLine
+ BLenc_start_0 BLenc_start_1 BLenc_start_2 BLenc_start_3
+ WLenc_start_0 WLenc_start_1 WLenc_start_2 WLenc_start_3
+ BLenc_0_0_0 BLenc_0_0_1 BLenc_0_0_2 BLenc_0_0_3 BLenc_0_1_0 BLenc_0_1_1 BLenc_0_1_2 BLenc_0_1_3
+ WLenc_0_0_0 WLenc_0_0_1 WLenc_0_0_2 WLenc_0_0_3 WLenc_0_1_0 WLenc_0_1_1 WLenc_0_1_2 WLenc_0_1_3
+ GBenable_0
+ LBenable_0 LBenable_1) drivers // line drives: kiest local en global block

xNot_ref_0 (LBenable_0 LBenbar_0 vdd_0 vss PBulkLine NBulkLine) inverter // inv localblok enble voor ref
xNot_ref_1 (LBenable_1 LBenbar_1 vdd_0 vss PBulkLine NBulkLine) inverter

xGB0 (vdd_0 vdd_1 vdd_2 vdd_3 vss NBulkLine PBulkLine
+WLenc_0_0_0 WLenc_0_0_1 WLenc_0_0_2 WLenc_0_0_3 WLenc_0_1_0 WLenc_0_1_1 WLenc_0_1_2 WLenc_0_1_3
+BLenc_0_0_0 BLenc_0_0_1 BLenc_0_0_2 BLenc_0_0_3 BLenc_0_1_0 BLenc_0_1_1 BLenc_0_1_2 BLenc_0_1_3
+LBenable_0 LBenable_1 LBenbar_0 LBenbar_1 GBenable_0
+InOut_0 InOutbar_0 SA_SH_0 EnableSAP_0 EnableSAN_0)
+globalblock Rcell_0_0_0 = Rcell_0_0_0_0 Rcell_0_0_1 = Rcell_0_0_0_1 Rcell_0_0_2 = Rcell_0_0_0_2 Rcell_0_0_3 = Rcell_0_0_0_3 Rcell_0_0_4 = Rcell_0_0_0_4 Rcell_0_0_5 = Rcell_0_0_0_5 Rcell_0_0_6 = Rcell_0_0_0_6 Rcell_0_0_7 = Rcell_0_0_0_7 Rcell_0_0_8 = Rcell_0_0_0_8 Rcell_0_0_9 = Rcell_0_0_0_9 Rcell_0_0_10 = Rcell_0_0_0_10 Rcell_0_0_11 = Rcell_0_0_0_11 Rcell_0_0_12 = Rcell_0_0_0_12 Rcell_0_0_13 = Rcell_0_0_0_13 Rcell_0_0_14 = Rcell_0_0_0_14 Rcell_0_0_15 = Rcell_0_0_0_15 Rcell_0_1_0 = Rcell_0_0_1_0 Rcell_0_1_1 = Rcell_0_0_1_1 Rcell_0_1_2 = Rcell_0_0_1_2 Rcell_0_1_3 = Rcell_0_0_1_3 Rcell_0_1_4 = Rcell_0_0_1_4 Rcell_0_1_5 = Rcell_0_0_1_5 Rcell_0_1_6 = Rcell_0_0_1_6 Rcell_0_1_7 = Rcell_0_0_1_7 Rcell_0_1_8 = Rcell_0_0_1_8 Rcell_0_1_9 = Rcell_0_0_1_9 Rcell_0_1_10 = Rcell_0_0_1_10 Rcell_0_1_11 = Rcell_0_0_1_11 Rcell_0_1_12 = Rcell_0_0_1_12 Rcell_0_1_13 = Rcell_0_0_1_13 Rcell_0_1_14 = Rcell_0_0_1_14 Rcell_0_1_15 = Rcell_0_0_1_15 Rcell_0_2_0 = Rcell_0_0_2_0 Rcell_0_2_1 = Rcell_0_0_2_1 Rcell_0_2_2 = Rcell_0_0_2_2 Rcell_0_2_3 = Rcell_0_0_2_3 Rcell_0_2_4 = Rcell_0_0_2_4 Rcell_0_2_5 = Rcell_0_0_2_5 Rcell_0_2_6 = Rcell_0_0_2_6 Rcell_0_2_7 = Rcell_0_0_2_7 Rcell_0_2_8 = Rcell_0_0_2_8 Rcell_0_2_9 = Rcell_0_0_2_9 Rcell_0_2_10 = Rcell_0_0_2_10 Rcell_0_2_11 = Rcell_0_0_2_11 Rcell_0_2_12 = Rcell_0_0_2_12 Rcell_0_2_13 = Rcell_0_0_2_13 Rcell_0_2_14 = Rcell_0_0_2_14 Rcell_0_2_15 = Rcell_0_0_2_15 Rcell_0_3_0 = Rcell_0_0_3_0 Rcell_0_3_1 = Rcell_0_0_3_1 Rcell_0_3_2 = Rcell_0_0_3_2 Rcell_0_3_3 = Rcell_0_0_3_3 Rcell_0_3_4 = Rcell_0_0_3_4 Rcell_0_3_5 = Rcell_0_0_3_5 Rcell_0_3_6 = Rcell_0_0_3_6 Rcell_0_3_7 = Rcell_0_0_3_7 Rcell_0_3_8 = Rcell_0_0_3_8 Rcell_0_3_9 = Rcell_0_0_3_9 Rcell_0_3_10 = Rcell_0_0_3_10 Rcell_0_3_11 = Rcell_0_0_3_11 Rcell_0_3_12 = Rcell_0_0_3_12 Rcell_0_3_13 = Rcell_0_0_3_13 Rcell_0_3_14 = Rcell_0_0_3_14 Rcell_0_3_15 = Rcell_0_0_3_15 Rcell_0_4_0 = Rcell_0_0_4_0 Rcell_0_4_1 = Rcell_0_0_4_1 Rcell_0_4_2 = Rcell_0_0_4_2 Rcell_0_4_3 = Rcell_0_0_4_3 Rcell_0_4_4 = Rcell_0_0_4_4 Rcell_0_4_5 = Rcell_0_0_4_5 Rcell_0_4_6 = Rcell_0_0_4_6 Rcell_0_4_7 = Rcell_0_0_4_7 Rcell_0_4_8 = Rcell_0_0_4_8 Rcell_0_4_9 = Rcell_0_0_4_9 Rcell_0_4_10 = Rcell_0_0_4_10 Rcell_0_4_11 = Rcell_0_0_4_11 Rcell_0_4_12 = Rcell_0_0_4_12 Rcell_0_4_13 = Rcell_0_0_4_13 Rcell_0_4_14 = Rcell_0_0_4_14 Rcell_0_4_15 = Rcell_0_0_4_15 Rcell_0_5_0 = Rcell_0_0_5_0 Rcell_0_5_1 = Rcell_0_0_5_1 Rcell_0_5_2 = Rcell_0_0_5_2 Rcell_0_5_3 = Rcell_0_0_5_3 Rcell_0_5_4 = Rcell_0_0_5_4 Rcell_0_5_5 = Rcell_0_0_5_5 Rcell_0_5_6 = Rcell_0_0_5_6 Rcell_0_5_7 = Rcell_0_0_5_7 Rcell_0_5_8 = Rcell_0_0_5_8 Rcell_0_5_9 = Rcell_0_0_5_9 Rcell_0_5_10 = Rcell_0_0_5_10 Rcell_0_5_11 = Rcell_0_0_5_11 Rcell_0_5_12 = Rcell_0_0_5_12 Rcell_0_5_13 = Rcell_0_0_5_13 Rcell_0_5_14 = Rcell_0_0_5_14 Rcell_0_5_15 = Rcell_0_0_5_15 Rcell_0_6_0 = Rcell_0_0_6_0 Rcell_0_6_1 = Rcell_0_0_6_1 Rcell_0_6_2 = Rcell_0_0_6_2 Rcell_0_6_3 = Rcell_0_0_6_3 Rcell_0_6_4 = Rcell_0_0_6_4 Rcell_0_6_5 = Rcell_0_0_6_5 Rcell_0_6_6 = Rcell_0_0_6_6 Rcell_0_6_7 = Rcell_0_0_6_7 Rcell_0_6_8 = Rcell_0_0_6_8 Rcell_0_6_9 = Rcell_0_0_6_9 Rcell_0_6_10 = Rcell_0_0_6_10 Rcell_0_6_11 = Rcell_0_0_6_11 Rcell_0_6_12 = Rcell_0_0_6_12 Rcell_0_6_13 = Rcell_0_0_6_13 Rcell_0_6_14 = Rcell_0_0_6_14 Rcell_0_6_15 = Rcell_0_0_6_15 Rcell_0_7_0 = Rcell_0_0_7_0 Rcell_0_7_1 = Rcell_0_0_7_1 Rcell_0_7_2 = Rcell_0_0_7_2 Rcell_0_7_3 = Rcell_0_0_7_3 Rcell_0_7_4 = Rcell_0_0_7_4 Rcell_0_7_5 = Rcell_0_0_7_5 Rcell_0_7_6 = Rcell_0_0_7_6 Rcell_0_7_7 = Rcell_0_0_7_7 Rcell_0_7_8 = Rcell_0_0_7_8 Rcell_0_7_9 = Rcell_0_0_7_9 Rcell_0_7_10 = Rcell_0_0_7_10 Rcell_0_7_11 = Rcell_0_0_7_11 Rcell_0_7_12 = Rcell_0_0_7_12 Rcell_0_7_13 = Rcell_0_0_7_13 Rcell_0_7_14 = Rcell_0_0_7_14 Rcell_0_7_15 = Rcell_0_0_7_15 Rcell_0_8_0 = Rcell_0_0_8_0 Rcell_0_8_1 = Rcell_0_0_8_1 Rcell_0_8_2 = Rcell_0_0_8_2 Rcell_0_8_3 = Rcell_0_0_8_3 Rcell_0_8_4 = Rcell_0_0_8_4 Rcell_0_8_5 = Rcell_0_0_8_5 Rcell_0_8_6 = Rcell_0_0_8_6 Rcell_0_8_7 = Rcell_0_0_8_7 Rcell_0_8_8 = Rcell_0_0_8_8 Rcell_0_8_9 = Rcell_0_0_8_9 Rcell_0_8_10 = Rcell_0_0_8_10 Rcell_0_8_11 = Rcell_0_0_8_11 Rcell_0_8_12 = Rcell_0_0_8_12 Rcell_0_8_13 = Rcell_0_0_8_13 Rcell_0_8_14 = Rcell_0_0_8_14 Rcell_0_8_15 = Rcell_0_0_8_15 Rcell_0_9_0 = Rcell_0_0_9_0 Rcell_0_9_1 = Rcell_0_0_9_1 Rcell_0_9_2 = Rcell_0_0_9_2 Rcell_0_9_3 = Rcell_0_0_9_3 Rcell_0_9_4 = Rcell_0_0_9_4 Rcell_0_9_5 = Rcell_0_0_9_5 Rcell_0_9_6 = Rcell_0_0_9_6 Rcell_0_9_7 = Rcell_0_0_9_7 Rcell_0_9_8 = Rcell_0_0_9_8 Rcell_0_9_9 = Rcell_0_0_9_9 Rcell_0_9_10 = Rcell_0_0_9_10 Rcell_0_9_11 = Rcell_0_0_9_11 Rcell_0_9_12 = Rcell_0_0_9_12 Rcell_0_9_13 = Rcell_0_0_9_13 Rcell_0_9_14 = Rcell_0_0_9_14 Rcell_0_9_15 = Rcell_0_0_9_15 Rcell_0_10_0 = Rcell_0_0_10_0 Rcell_0_10_1 = Rcell_0_0_10_1 Rcell_0_10_2 = Rcell_0_0_10_2 Rcell_0_10_3 = Rcell_0_0_10_3 Rcell_0_10_4 = Rcell_0_0_10_4 Rcell_0_10_5 = Rcell_0_0_10_5 Rcell_0_10_6 = Rcell_0_0_10_6 Rcell_0_10_7 = Rcell_0_0_10_7 Rcell_0_10_8 = Rcell_0_0_10_8 Rcell_0_10_9 = Rcell_0_0_10_9 Rcell_0_10_10 = Rcell_0_0_10_10 Rcell_0_10_11 = Rcell_0_0_10_11 Rcell_0_10_12 = Rcell_0_0_10_12 Rcell_0_10_13 = Rcell_0_0_10_13 Rcell_0_10_14 = Rcell_0_0_10_14 Rcell_0_10_15 = Rcell_0_0_10_15 Rcell_0_11_0 = Rcell_0_0_11_0 Rcell_0_11_1 = Rcell_0_0_11_1 Rcell_0_11_2 = Rcell_0_0_11_2 Rcell_0_11_3 = Rcell_0_0_11_3 Rcell_0_11_4 = Rcell_0_0_11_4 Rcell_0_11_5 = Rcell_0_0_11_5 Rcell_0_11_6 = Rcell_0_0_11_6 Rcell_0_11_7 = Rcell_0_0_11_7 Rcell_0_11_8 = Rcell_0_0_11_8 Rcell_0_11_9 = Rcell_0_0_11_9 Rcell_0_11_10 = Rcell_0_0_11_10 Rcell_0_11_11 = Rcell_0_0_11_11 Rcell_0_11_12 = Rcell_0_0_11_12 Rcell_0_11_13 = Rcell_0_0_11_13 Rcell_0_11_14 = Rcell_0_0_11_14 Rcell_0_11_15 = Rcell_0_0_11_15 Rcell_0_12_0 = Rcell_0_0_12_0 Rcell_0_12_1 = Rcell_0_0_12_1 Rcell_0_12_2 = Rcell_0_0_12_2 Rcell_0_12_3 = Rcell_0_0_12_3 Rcell_0_12_4 = Rcell_0_0_12_4 Rcell_0_12_5 = Rcell_0_0_12_5 Rcell_0_12_6 = Rcell_0_0_12_6 Rcell_0_12_7 = Rcell_0_0_12_7 Rcell_0_12_8 = Rcell_0_0_12_8 Rcell_0_12_9 = Rcell_0_0_12_9 Rcell_0_12_10 = Rcell_0_0_12_10 Rcell_0_12_11 = Rcell_0_0_12_11 Rcell_0_12_12 = Rcell_0_0_12_12 Rcell_0_12_13 = Rcell_0_0_12_13 Rcell_0_12_14 = Rcell_0_0_12_14 Rcell_0_12_15 = Rcell_0_0_12_15 Rcell_0_13_0 = Rcell_0_0_13_0 Rcell_0_13_1 = Rcell_0_0_13_1 Rcell_0_13_2 = Rcell_0_0_13_2 Rcell_0_13_3 = Rcell_0_0_13_3 Rcell_0_13_4 = Rcell_0_0_13_4 Rcell_0_13_5 = Rcell_0_0_13_5 Rcell_0_13_6 = Rcell_0_0_13_6 Rcell_0_13_7 = Rcell_0_0_13_7 Rcell_0_13_8 = Rcell_0_0_13_8 Rcell_0_13_9 = Rcell_0_0_13_9 Rcell_0_13_10 = Rcell_0_0_13_10 Rcell_0_13_11 = Rcell_0_0_13_11 Rcell_0_13_12 = Rcell_0_0_13_12 Rcell_0_13_13 = Rcell_0_0_13_13 Rcell_0_13_14 = Rcell_0_0_13_14 Rcell_0_13_15 = Rcell_0_0_13_15 Rcell_0_14_0 = Rcell_0_0_14_0 Rcell_0_14_1 = Rcell_0_0_14_1 Rcell_0_14_2 = Rcell_0_0_14_2 Rcell_0_14_3 = Rcell_0_0_14_3 Rcell_0_14_4 = Rcell_0_0_14_4 Rcell_0_14_5 = Rcell_0_0_14_5 Rcell_0_14_6 = Rcell_0_0_14_6 Rcell_0_14_7 = Rcell_0_0_14_7 Rcell_0_14_8 = Rcell_0_0_14_8 Rcell_0_14_9 = Rcell_0_0_14_9 Rcell_0_14_10 = Rcell_0_0_14_10 Rcell_0_14_11 = Rcell_0_0_14_11 Rcell_0_14_12 = Rcell_0_0_14_12 Rcell_0_14_13 = Rcell_0_0_14_13 Rcell_0_14_14 = Rcell_0_0_14_14 Rcell_0_14_15 = Rcell_0_0_14_15 Rcell_0_15_0 = Rcell_0_0_15_0 Rcell_0_15_1 = Rcell_0_0_15_1 Rcell_0_15_2 = Rcell_0_0_15_2 Rcell_0_15_3 = Rcell_0_0_15_3 Rcell_0_15_4 = Rcell_0_0_15_4 Rcell_0_15_5 = Rcell_0_0_15_5 Rcell_0_15_6 = Rcell_0_0_15_6 Rcell_0_15_7 = Rcell_0_0_15_7 Rcell_0_15_8 = Rcell_0_0_15_8 Rcell_0_15_9 = Rcell_0_0_15_9 Rcell_0_15_10 = Rcell_0_0_15_10 Rcell_0_15_11 = Rcell_0_0_15_11 Rcell_0_15_12 = Rcell_0_0_15_12 Rcell_0_15_13 = Rcell_0_0_15_13 Rcell_0_15_14 = Rcell_0_0_15_14 Rcell_0_15_15 = Rcell_0_0_15_15 Rcell_1_0_0 = Rcell_0_1_0_0 Rcell_1_0_1 = Rcell_0_1_0_1 Rcell_1_0_2 = Rcell_0_1_0_2 Rcell_1_0_3 = Rcell_0_1_0_3 Rcell_1_0_4 = Rcell_0_1_0_4 Rcell_1_0_5 = Rcell_0_1_0_5 Rcell_1_0_6 = Rcell_0_1_0_6 Rcell_1_0_7 = Rcell_0_1_0_7 Rcell_1_0_8 = Rcell_0_1_0_8 Rcell_1_0_9 = Rcell_0_1_0_9 Rcell_1_0_10 = Rcell_0_1_0_10 Rcell_1_0_11 = Rcell_0_1_0_11 Rcell_1_0_12 = Rcell_0_1_0_12 Rcell_1_0_13 = Rcell_0_1_0_13 Rcell_1_0_14 = Rcell_0_1_0_14 Rcell_1_0_15 = Rcell_0_1_0_15 Rcell_1_1_0 = Rcell_0_1_1_0 Rcell_1_1_1 = Rcell_0_1_1_1 Rcell_1_1_2 = Rcell_0_1_1_2 Rcell_1_1_3 = Rcell_0_1_1_3 Rcell_1_1_4 = Rcell_0_1_1_4 Rcell_1_1_5 = Rcell_0_1_1_5 Rcell_1_1_6 = Rcell_0_1_1_6 Rcell_1_1_7 = Rcell_0_1_1_7 Rcell_1_1_8 = Rcell_0_1_1_8 Rcell_1_1_9 = Rcell_0_1_1_9 Rcell_1_1_10 = Rcell_0_1_1_10 Rcell_1_1_11 = Rcell_0_1_1_11 Rcell_1_1_12 = Rcell_0_1_1_12 Rcell_1_1_13 = Rcell_0_1_1_13 Rcell_1_1_14 = Rcell_0_1_1_14 Rcell_1_1_15 = Rcell_0_1_1_15 Rcell_1_2_0 = Rcell_0_1_2_0 Rcell_1_2_1 = Rcell_0_1_2_1 Rcell_1_2_2 = Rcell_0_1_2_2 Rcell_1_2_3 = Rcell_0_1_2_3 Rcell_1_2_4 = Rcell_0_1_2_4 Rcell_1_2_5 = Rcell_0_1_2_5 Rcell_1_2_6 = Rcell_0_1_2_6 Rcell_1_2_7 = Rcell_0_1_2_7 Rcell_1_2_8 = Rcell_0_1_2_8 Rcell_1_2_9 = Rcell_0_1_2_9 Rcell_1_2_10 = Rcell_0_1_2_10 Rcell_1_2_11 = Rcell_0_1_2_11 Rcell_1_2_12 = Rcell_0_1_2_12 Rcell_1_2_13 = Rcell_0_1_2_13 Rcell_1_2_14 = Rcell_0_1_2_14 Rcell_1_2_15 = Rcell_0_1_2_15 Rcell_1_3_0 = Rcell_0_1_3_0 Rcell_1_3_1 = Rcell_0_1_3_1 Rcell_1_3_2 = Rcell_0_1_3_2 Rcell_1_3_3 = Rcell_0_1_3_3 Rcell_1_3_4 = Rcell_0_1_3_4 Rcell_1_3_5 = Rcell_0_1_3_5 Rcell_1_3_6 = Rcell_0_1_3_6 Rcell_1_3_7 = Rcell_0_1_3_7 Rcell_1_3_8 = Rcell_0_1_3_8 Rcell_1_3_9 = Rcell_0_1_3_9 Rcell_1_3_10 = Rcell_0_1_3_10 Rcell_1_3_11 = Rcell_0_1_3_11 Rcell_1_3_12 = Rcell_0_1_3_12 Rcell_1_3_13 = Rcell_0_1_3_13 Rcell_1_3_14 = Rcell_0_1_3_14 Rcell_1_3_15 = Rcell_0_1_3_15 Rcell_1_4_0 = Rcell_0_1_4_0 Rcell_1_4_1 = Rcell_0_1_4_1 Rcell_1_4_2 = Rcell_0_1_4_2 Rcell_1_4_3 = Rcell_0_1_4_3 Rcell_1_4_4 = Rcell_0_1_4_4 Rcell_1_4_5 = Rcell_0_1_4_5 Rcell_1_4_6 = Rcell_0_1_4_6 Rcell_1_4_7 = Rcell_0_1_4_7 Rcell_1_4_8 = Rcell_0_1_4_8 Rcell_1_4_9 = Rcell_0_1_4_9 Rcell_1_4_10 = Rcell_0_1_4_10 Rcell_1_4_11 = Rcell_0_1_4_11 Rcell_1_4_12 = Rcell_0_1_4_12 Rcell_1_4_13 = Rcell_0_1_4_13 Rcell_1_4_14 = Rcell_0_1_4_14 Rcell_1_4_15 = Rcell_0_1_4_15 Rcell_1_5_0 = Rcell_0_1_5_0 Rcell_1_5_1 = Rcell_0_1_5_1 Rcell_1_5_2 = Rcell_0_1_5_2 Rcell_1_5_3 = Rcell_0_1_5_3 Rcell_1_5_4 = Rcell_0_1_5_4 Rcell_1_5_5 = Rcell_0_1_5_5 Rcell_1_5_6 = Rcell_0_1_5_6 Rcell_1_5_7 = Rcell_0_1_5_7 Rcell_1_5_8 = Rcell_0_1_5_8 Rcell_1_5_9 = Rcell_0_1_5_9 Rcell_1_5_10 = Rcell_0_1_5_10 Rcell_1_5_11 = Rcell_0_1_5_11 Rcell_1_5_12 = Rcell_0_1_5_12 Rcell_1_5_13 = Rcell_0_1_5_13 Rcell_1_5_14 = Rcell_0_1_5_14 Rcell_1_5_15 = Rcell_0_1_5_15 Rcell_1_6_0 = Rcell_0_1_6_0 Rcell_1_6_1 = Rcell_0_1_6_1 Rcell_1_6_2 = Rcell_0_1_6_2 Rcell_1_6_3 = Rcell_0_1_6_3 Rcell_1_6_4 = Rcell_0_1_6_4 Rcell_1_6_5 = Rcell_0_1_6_5 Rcell_1_6_6 = Rcell_0_1_6_6 Rcell_1_6_7 = Rcell_0_1_6_7 Rcell_1_6_8 = Rcell_0_1_6_8 Rcell_1_6_9 = Rcell_0_1_6_9 Rcell_1_6_10 = Rcell_0_1_6_10 Rcell_1_6_11 = Rcell_0_1_6_11 Rcell_1_6_12 = Rcell_0_1_6_12 Rcell_1_6_13 = Rcell_0_1_6_13 Rcell_1_6_14 = Rcell_0_1_6_14 Rcell_1_6_15 = Rcell_0_1_6_15 Rcell_1_7_0 = Rcell_0_1_7_0 Rcell_1_7_1 = Rcell_0_1_7_1 Rcell_1_7_2 = Rcell_0_1_7_2 Rcell_1_7_3 = Rcell_0_1_7_3 Rcell_1_7_4 = Rcell_0_1_7_4 Rcell_1_7_5 = Rcell_0_1_7_5 Rcell_1_7_6 = Rcell_0_1_7_6 Rcell_1_7_7 = Rcell_0_1_7_7 Rcell_1_7_8 = Rcell_0_1_7_8 Rcell_1_7_9 = Rcell_0_1_7_9 Rcell_1_7_10 = Rcell_0_1_7_10 Rcell_1_7_11 = Rcell_0_1_7_11 Rcell_1_7_12 = Rcell_0_1_7_12 Rcell_1_7_13 = Rcell_0_1_7_13 Rcell_1_7_14 = Rcell_0_1_7_14 Rcell_1_7_15 = Rcell_0_1_7_15 Rcell_1_8_0 = Rcell_0_1_8_0 Rcell_1_8_1 = Rcell_0_1_8_1 Rcell_1_8_2 = Rcell_0_1_8_2 Rcell_1_8_3 = Rcell_0_1_8_3 Rcell_1_8_4 = Rcell_0_1_8_4 Rcell_1_8_5 = Rcell_0_1_8_5 Rcell_1_8_6 = Rcell_0_1_8_6 Rcell_1_8_7 = Rcell_0_1_8_7 Rcell_1_8_8 = Rcell_0_1_8_8 Rcell_1_8_9 = Rcell_0_1_8_9 Rcell_1_8_10 = Rcell_0_1_8_10 Rcell_1_8_11 = Rcell_0_1_8_11 Rcell_1_8_12 = Rcell_0_1_8_12 Rcell_1_8_13 = Rcell_0_1_8_13 Rcell_1_8_14 = Rcell_0_1_8_14 Rcell_1_8_15 = Rcell_0_1_8_15 Rcell_1_9_0 = Rcell_0_1_9_0 Rcell_1_9_1 = Rcell_0_1_9_1 Rcell_1_9_2 = Rcell_0_1_9_2 Rcell_1_9_3 = Rcell_0_1_9_3 Rcell_1_9_4 = Rcell_0_1_9_4 Rcell_1_9_5 = Rcell_0_1_9_5 Rcell_1_9_6 = Rcell_0_1_9_6 Rcell_1_9_7 = Rcell_0_1_9_7 Rcell_1_9_8 = Rcell_0_1_9_8 Rcell_1_9_9 = Rcell_0_1_9_9 Rcell_1_9_10 = Rcell_0_1_9_10 Rcell_1_9_11 = Rcell_0_1_9_11 Rcell_1_9_12 = Rcell_0_1_9_12 Rcell_1_9_13 = Rcell_0_1_9_13 Rcell_1_9_14 = Rcell_0_1_9_14 Rcell_1_9_15 = Rcell_0_1_9_15 Rcell_1_10_0 = Rcell_0_1_10_0 Rcell_1_10_1 = Rcell_0_1_10_1 Rcell_1_10_2 = Rcell_0_1_10_2 Rcell_1_10_3 = Rcell_0_1_10_3 Rcell_1_10_4 = Rcell_0_1_10_4 Rcell_1_10_5 = Rcell_0_1_10_5 Rcell_1_10_6 = Rcell_0_1_10_6 Rcell_1_10_7 = Rcell_0_1_10_7 Rcell_1_10_8 = Rcell_0_1_10_8 Rcell_1_10_9 = Rcell_0_1_10_9 Rcell_1_10_10 = Rcell_0_1_10_10 Rcell_1_10_11 = Rcell_0_1_10_11 Rcell_1_10_12 = Rcell_0_1_10_12 Rcell_1_10_13 = Rcell_0_1_10_13 Rcell_1_10_14 = Rcell_0_1_10_14 Rcell_1_10_15 = Rcell_0_1_10_15 Rcell_1_11_0 = Rcell_0_1_11_0 Rcell_1_11_1 = Rcell_0_1_11_1 Rcell_1_11_2 = Rcell_0_1_11_2 Rcell_1_11_3 = Rcell_0_1_11_3 Rcell_1_11_4 = Rcell_0_1_11_4 Rcell_1_11_5 = Rcell_0_1_11_5 Rcell_1_11_6 = Rcell_0_1_11_6 Rcell_1_11_7 = Rcell_0_1_11_7 Rcell_1_11_8 = Rcell_0_1_11_8 Rcell_1_11_9 = Rcell_0_1_11_9 Rcell_1_11_10 = Rcell_0_1_11_10 Rcell_1_11_11 = Rcell_0_1_11_11 Rcell_1_11_12 = Rcell_0_1_11_12 Rcell_1_11_13 = Rcell_0_1_11_13 Rcell_1_11_14 = Rcell_0_1_11_14 Rcell_1_11_15 = Rcell_0_1_11_15 Rcell_1_12_0 = Rcell_0_1_12_0 Rcell_1_12_1 = Rcell_0_1_12_1 Rcell_1_12_2 = Rcell_0_1_12_2 Rcell_1_12_3 = Rcell_0_1_12_3 Rcell_1_12_4 = Rcell_0_1_12_4 Rcell_1_12_5 = Rcell_0_1_12_5 Rcell_1_12_6 = Rcell_0_1_12_6 Rcell_1_12_7 = Rcell_0_1_12_7 Rcell_1_12_8 = Rcell_0_1_12_8 Rcell_1_12_9 = Rcell_0_1_12_9 Rcell_1_12_10 = Rcell_0_1_12_10 Rcell_1_12_11 = Rcell_0_1_12_11 Rcell_1_12_12 = Rcell_0_1_12_12 Rcell_1_12_13 = Rcell_0_1_12_13 Rcell_1_12_14 = Rcell_0_1_12_14 Rcell_1_12_15 = Rcell_0_1_12_15 Rcell_1_13_0 = Rcell_0_1_13_0 Rcell_1_13_1 = Rcell_0_1_13_1 Rcell_1_13_2 = Rcell_0_1_13_2 Rcell_1_13_3 = Rcell_0_1_13_3 Rcell_1_13_4 = Rcell_0_1_13_4 Rcell_1_13_5 = Rcell_0_1_13_5 Rcell_1_13_6 = Rcell_0_1_13_6 Rcell_1_13_7 = Rcell_0_1_13_7 Rcell_1_13_8 = Rcell_0_1_13_8 Rcell_1_13_9 = Rcell_0_1_13_9 Rcell_1_13_10 = Rcell_0_1_13_10 Rcell_1_13_11 = Rcell_0_1_13_11 Rcell_1_13_12 = Rcell_0_1_13_12 Rcell_1_13_13 = Rcell_0_1_13_13 Rcell_1_13_14 = Rcell_0_1_13_14 Rcell_1_13_15 = Rcell_0_1_13_15 Rcell_1_14_0 = Rcell_0_1_14_0 Rcell_1_14_1 = Rcell_0_1_14_1 Rcell_1_14_2 = Rcell_0_1_14_2 Rcell_1_14_3 = Rcell_0_1_14_3 Rcell_1_14_4 = Rcell_0_1_14_4 Rcell_1_14_5 = Rcell_0_1_14_5 Rcell_1_14_6 = Rcell_0_1_14_6 Rcell_1_14_7 = Rcell_0_1_14_7 Rcell_1_14_8 = Rcell_0_1_14_8 Rcell_1_14_9 = Rcell_0_1_14_9 Rcell_1_14_10 = Rcell_0_1_14_10 Rcell_1_14_11 = Rcell_0_1_14_11 Rcell_1_14_12 = Rcell_0_1_14_12 Rcell_1_14_13 = Rcell_0_1_14_13 Rcell_1_14_14 = Rcell_0_1_14_14 Rcell_1_14_15 = Rcell_0_1_14_15 Rcell_1_15_0 = Rcell_0_1_15_0 Rcell_1_15_1 = Rcell_0_1_15_1 Rcell_1_15_2 = Rcell_0_1_15_2 Rcell_1_15_3 = Rcell_0_1_15_3 Rcell_1_15_4 = Rcell_0_1_15_4 Rcell_1_15_5 = Rcell_0_1_15_5 Rcell_1_15_6 = Rcell_0_1_15_6 Rcell_1_15_7 = Rcell_0_1_15_7 Rcell_1_15_8 = Rcell_0_1_15_8 Rcell_1_15_9 = Rcell_0_1_15_9 Rcell_1_15_10 = Rcell_0_1_15_10 Rcell_1_15_11 = Rcell_0_1_15_11 Rcell_1_15_12 = Rcell_0_1_15_12 Rcell_1_15_13 = Rcell_0_1_15_13 Rcell_1_15_14 = Rcell_0_1_15_14 Rcell_1_15_15 = Rcell_0_1_15_15 //maak GB aan
xNOTout0 (InOutbar_0 Out_0 vdd_3 vss PBulkLine NBulkLine) inverter // inverter achter SA
xNOToutbar0 (InOut_0 Outbar_0 vdd_3 vss PBulkLine NBulkLine) inverter

VGBen0 (GBenable_0 0) vsource type=pwl wave=waveEnGB_0
VLBen0 (LBenable_0 0) vsource type=pwl wave=waveEnLB_0
VLBen1 (LBenable_1 0) vsource type=pwl wave=waveEnLB_1
VBLenc0 (BLenc_start_0 0) vsource type=pwl wave=waveBLstart_0
VBLenc1 (BLenc_start_1 0) vsource type=pwl wave=waveBLstart_1
VBLenc2 (BLenc_start_2 0) vsource type=pwl wave=waveBLstart_2
VBLenc3 (BLenc_start_3 0) vsource type=pwl wave=waveBLstart_3
VWLenc0 (WLenc_start_0 0) vsource type=pwl wave=waveWLstart_0
VWLenc1 (WLenc_start_1 0) vsource type=pwl wave=waveWLstart_1
VWLenc2 (WLenc_start_2 0) vsource type=pwl wave=waveWLstart_2
VWLenc3 (WLenc_start_3 0) vsource type=pwl wave=waveWLstart_3

VSH (SA_SH_0 0) vsource type=pwl wave=wave_SA_SH
VSAN (EnableSAN_0 0) vsource type=pwl wave=wave_SAN
VSAP (EnableSAP_0 0) vsource type=pwl wave=wave_SAP

Vvdd_0     ( vdd_0     0 ) vsource dc=vdd // logic
Vvdd_1     ( vdd_1     0 ) vsource dc=vdd // SA
Vvdd_2     ( vdd_2     0 ) vsource dc=vdd // mem array
Vvdd_3     ( vdd_3     0 ) vsource dc=vdd // buffers
VvddBulk ( PBulkLine 0 ) vsource dc=vdd
Vvss     ( vss     0 ) vsource dc=0
VvssBulk ( NBulkLine 0 ) vsource dc=0

save InOut_0
save xGB0.*
save Vvdd_0:p
save Vvdd_1:p
save Vvdd_2:p
save Vvdd_3:p

mymc montecarlo
+ donominal=no variations=mismatch
+ seed=1234
+ numruns=numberofruns
+ firstrun=1
+ saveprocessparams=yes
+ savefamilyplots= yes {
mytran tran stop=simlength method=trap
}

option1 options rawfmt = psfascii
option2 options dc_pivot_check = yes
//cap info what=captab where=file file="%C:r.info.what"
