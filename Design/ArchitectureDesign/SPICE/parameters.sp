simulator lang=spectre

parameters PWmin = 100n                         //MinimalTransistorWidth
parameters PLmin = 45n                          //MinimalTransistorLenght
parameters WChargeBL = 1e-07         //BitLineChargerWidth(perBL)
parameters WBias = 1.5e-07
parameters WDischargeBL = 1.8e-07   //BitLineDischargerWidth(perBL)
parameters WDischargeSL = 2.25e-07   //SourceLineDischargerWidth(perBL)
parameters Cpar = 0.18e-15                      //ParasiticCapacitor(perCell)
parameters PWn = 1e-07                     //DifferentialNpairWidth(perSA)
parameters PWp = 1e-07                     //DifferentialPpairWidth(perSA)
parameters PWpenable = 1e-07         //SenseAmpEnablePWidth(perSA)
parameters PWnenable = 1e-07         //SenseAmpEnableNWidth(perSA)
parameters PWmuxLB = 2e-07                //PassgateWidth(perMuxLB)
parameters PWmuxGB = 2e-07                //PassgateWidth(perMuxGB)

parameters numberofruns = 1
parameters enableMismatch = 0   //Mismatch
parameters simlength = 3e-08

parameters RMEMHigh = 32500;
parameters RMEMLow = 7500;

parameters Rcell_0_0_0_0 = RMEMLow
parameters Rcell_0_0_0_1 = RMEMLow
parameters Rcell_0_0_0_2 = RMEMLow
parameters Rcell_0_0_0_3 = RMEMLow
parameters Rcell_0_0_0_4 = RMEMHigh
parameters Rcell_0_0_0_5 = RMEMLow
parameters Rcell_0_0_0_6 = RMEMHigh
parameters Rcell_0_0_0_7 = RMEMLow
parameters Rcell_0_0_0_8 = RMEMLow
parameters Rcell_0_0_0_9 = RMEMHigh
parameters Rcell_0_0_0_10 = RMEMLow
parameters Rcell_0_0_0_11 = RMEMHigh
parameters Rcell_0_0_0_12 = RMEMLow
parameters Rcell_0_0_0_13 = RMEMHigh
parameters Rcell_0_0_0_14 = RMEMLow
parameters Rcell_0_0_0_15 = RMEMHigh
parameters Rcell_0_0_0_16 = RMEMLow
parameters Rcell_0_0_0_17 = RMEMHigh
parameters Rcell_0_0_0_18 = RMEMLow
parameters Rcell_0_0_0_19 = RMEMLow
parameters Rcell_0_0_0_20 = RMEMLow
parameters Rcell_0_0_0_21 = RMEMHigh
parameters Rcell_0_0_0_22 = RMEMLow
parameters Rcell_0_0_0_23 = RMEMLow
parameters Rcell_0_0_0_24 = RMEMHigh
parameters Rcell_0_0_0_25 = RMEMHigh
parameters Rcell_0_0_0_26 = RMEMLow
parameters Rcell_0_0_0_27 = RMEMHigh
parameters Rcell_0_0_0_28 = RMEMHigh
parameters Rcell_0_0_0_29 = RMEMLow
parameters Rcell_0_0_0_30 = RMEMHigh
parameters Rcell_0_0_0_31 = RMEMLow
parameters Rcell_0_0_0_32 = RMEMLow
parameters Rcell_0_0_0_33 = RMEMHigh
parameters Rcell_0_0_0_34 = RMEMHigh
parameters Rcell_0_0_0_35 = RMEMLow
parameters Rcell_0_0_0_36 = RMEMHigh
parameters Rcell_0_0_0_37 = RMEMHigh
parameters Rcell_0_0_0_38 = RMEMLow
parameters Rcell_0_0_0_39 = RMEMLow
parameters Rcell_0_0_0_40 = RMEMLow
parameters Rcell_0_0_0_41 = RMEMLow
parameters Rcell_0_0_0_42 = RMEMHigh
parameters Rcell_0_0_0_43 = RMEMLow
parameters Rcell_0_0_0_44 = RMEMHigh
parameters Rcell_0_0_0_45 = RMEMHigh
parameters Rcell_0_0_0_46 = RMEMHigh
parameters Rcell_0_0_0_47 = RMEMLow
parameters Rcell_0_0_0_48 = RMEMHigh
parameters Rcell_0_0_0_49 = RMEMHigh
parameters Rcell_0_0_0_50 = RMEMLow
parameters Rcell_0_0_0_51 = RMEMLow
parameters Rcell_0_0_0_52 = RMEMLow
parameters Rcell_0_0_0_53 = RMEMHigh
parameters Rcell_0_0_0_54 = RMEMHigh
parameters Rcell_0_0_0_55 = RMEMLow
parameters Rcell_0_0_0_56 = RMEMLow
parameters Rcell_0_0_0_57 = RMEMHigh
parameters Rcell_0_0_0_58 = RMEMHigh
parameters Rcell_0_0_0_59 = RMEMLow
parameters Rcell_0_0_0_60 = RMEMLow
parameters Rcell_0_0_0_61 = RMEMHigh
parameters Rcell_0_0_0_62 = RMEMHigh
parameters Rcell_0_0_0_63 = RMEMHigh
parameters Rcell_0_0_1_0 = RMEMHigh
parameters Rcell_0_0_1_1 = RMEMLow
parameters Rcell_0_0_1_2 = RMEMHigh
parameters Rcell_0_0_1_3 = RMEMHigh
parameters Rcell_0_0_1_4 = RMEMLow
parameters Rcell_0_0_1_5 = RMEMHigh
parameters Rcell_0_0_1_6 = RMEMHigh
parameters Rcell_0_0_1_7 = RMEMLow
parameters Rcell_0_0_1_8 = RMEMHigh
parameters Rcell_0_0_1_9 = RMEMHigh
parameters Rcell_0_0_1_10 = RMEMLow
parameters Rcell_0_0_1_11 = RMEMHigh
parameters Rcell_0_0_1_12 = RMEMHigh
parameters Rcell_0_0_1_13 = RMEMHigh
parameters Rcell_0_0_1_14 = RMEMHigh
parameters Rcell_0_0_1_15 = RMEMLow
parameters Rcell_0_0_1_16 = RMEMHigh
parameters Rcell_0_0_1_17 = RMEMLow
parameters Rcell_0_0_1_18 = RMEMHigh
parameters Rcell_0_0_1_19 = RMEMHigh
parameters Rcell_0_0_1_20 = RMEMLow
parameters Rcell_0_0_1_21 = RMEMLow
parameters Rcell_0_0_1_22 = RMEMHigh
parameters Rcell_0_0_1_23 = RMEMLow
parameters Rcell_0_0_1_24 = RMEMLow
parameters Rcell_0_0_1_25 = RMEMHigh
parameters Rcell_0_0_1_26 = RMEMLow
parameters Rcell_0_0_1_27 = RMEMLow
parameters Rcell_0_0_1_28 = RMEMLow
parameters Rcell_0_0_1_29 = RMEMHigh
parameters Rcell_0_0_1_30 = RMEMHigh
parameters Rcell_0_0_1_31 = RMEMHigh
parameters Rcell_0_0_1_32 = RMEMLow
parameters Rcell_0_0_1_33 = RMEMHigh
parameters Rcell_0_0_1_34 = RMEMLow
parameters Rcell_0_0_1_35 = RMEMHigh
parameters Rcell_0_0_1_36 = RMEMHigh
parameters Rcell_0_0_1_37 = RMEMLow
parameters Rcell_0_0_1_38 = RMEMHigh
parameters Rcell_0_0_1_39 = RMEMHigh
parameters Rcell_0_0_1_40 = RMEMHigh
parameters Rcell_0_0_1_41 = RMEMLow
parameters Rcell_0_0_1_42 = RMEMLow
parameters Rcell_0_0_1_43 = RMEMHigh
parameters Rcell_0_0_1_44 = RMEMLow
parameters Rcell_0_0_1_45 = RMEMLow
parameters Rcell_0_0_1_46 = RMEMHigh
parameters Rcell_0_0_1_47 = RMEMLow
parameters Rcell_0_0_1_48 = RMEMHigh
parameters Rcell_0_0_1_49 = RMEMHigh
parameters Rcell_0_0_1_50 = RMEMHigh
parameters Rcell_0_0_1_51 = RMEMLow
parameters Rcell_0_0_1_52 = RMEMHigh
parameters Rcell_0_0_1_53 = RMEMLow
parameters Rcell_0_0_1_54 = RMEMHigh
parameters Rcell_0_0_1_55 = RMEMHigh
parameters Rcell_0_0_1_56 = RMEMLow
parameters Rcell_0_0_1_57 = RMEMHigh
parameters Rcell_0_0_1_58 = RMEMHigh
parameters Rcell_0_0_1_59 = RMEMLow
parameters Rcell_0_0_1_60 = RMEMLow
parameters Rcell_0_0_1_61 = RMEMHigh
parameters Rcell_0_0_1_62 = RMEMLow
parameters Rcell_0_0_1_63 = RMEMLow
parameters Rcell_0_0_2_0 = RMEMLow
parameters Rcell_0_0_2_1 = RMEMHigh
parameters Rcell_0_0_2_2 = RMEMHigh
parameters Rcell_0_0_2_3 = RMEMLow
parameters Rcell_0_0_2_4 = RMEMHigh
parameters Rcell_0_0_2_5 = RMEMHigh
parameters Rcell_0_0_2_6 = RMEMLow
parameters Rcell_0_0_2_7 = RMEMLow
parameters Rcell_0_0_2_8 = RMEMLow
parameters Rcell_0_0_2_9 = RMEMHigh
parameters Rcell_0_0_2_10 = RMEMLow
parameters Rcell_0_0_2_11 = RMEMHigh
parameters Rcell_0_0_2_12 = RMEMLow
parameters Rcell_0_0_2_13 = RMEMLow
parameters Rcell_0_0_2_14 = RMEMHigh
parameters Rcell_0_0_2_15 = RMEMHigh
parameters Rcell_0_0_2_16 = RMEMLow
parameters Rcell_0_0_2_17 = RMEMHigh
parameters Rcell_0_0_2_18 = RMEMLow
parameters Rcell_0_0_2_19 = RMEMHigh
parameters Rcell_0_0_2_20 = RMEMHigh
parameters Rcell_0_0_2_21 = RMEMHigh
parameters Rcell_0_0_2_22 = RMEMHigh
parameters Rcell_0_0_2_23 = RMEMHigh
parameters Rcell_0_0_2_24 = RMEMLow
parameters Rcell_0_0_2_25 = RMEMHigh
parameters Rcell_0_0_2_26 = RMEMHigh
parameters Rcell_0_0_2_27 = RMEMHigh
parameters Rcell_0_0_2_28 = RMEMLow
parameters Rcell_0_0_2_29 = RMEMLow
parameters Rcell_0_0_2_30 = RMEMLow
parameters Rcell_0_0_2_31 = RMEMLow
parameters Rcell_0_0_2_32 = RMEMLow
parameters Rcell_0_0_2_33 = RMEMLow
parameters Rcell_0_0_2_34 = RMEMHigh
parameters Rcell_0_0_2_35 = RMEMHigh
parameters Rcell_0_0_2_36 = RMEMLow
parameters Rcell_0_0_2_37 = RMEMHigh
parameters Rcell_0_0_2_38 = RMEMHigh
parameters Rcell_0_0_2_39 = RMEMHigh
parameters Rcell_0_0_2_40 = RMEMHigh
parameters Rcell_0_0_2_41 = RMEMHigh
parameters Rcell_0_0_2_42 = RMEMLow
parameters Rcell_0_0_2_43 = RMEMHigh
parameters Rcell_0_0_2_44 = RMEMLow
parameters Rcell_0_0_2_45 = RMEMLow
parameters Rcell_0_0_2_46 = RMEMHigh
parameters Rcell_0_0_2_47 = RMEMLow
parameters Rcell_0_0_2_48 = RMEMLow
parameters Rcell_0_0_2_49 = RMEMLow
parameters Rcell_0_0_2_50 = RMEMHigh
parameters Rcell_0_0_2_51 = RMEMHigh
parameters Rcell_0_0_2_52 = RMEMHigh
parameters Rcell_0_0_2_53 = RMEMHigh
parameters Rcell_0_0_2_54 = RMEMHigh
parameters Rcell_0_0_2_55 = RMEMHigh
parameters Rcell_0_0_2_56 = RMEMLow
parameters Rcell_0_0_2_57 = RMEMHigh
parameters Rcell_0_0_2_58 = RMEMHigh
parameters Rcell_0_0_2_59 = RMEMLow
parameters Rcell_0_0_2_60 = RMEMLow
parameters Rcell_0_0_2_61 = RMEMHigh
parameters Rcell_0_0_2_62 = RMEMLow
parameters Rcell_0_0_2_63 = RMEMHigh
parameters Rcell_0_0_3_0 = RMEMLow
parameters Rcell_0_0_3_1 = RMEMHigh
parameters Rcell_0_0_3_2 = RMEMLow
parameters Rcell_0_0_3_3 = RMEMHigh
parameters Rcell_0_0_3_4 = RMEMHigh
parameters Rcell_0_0_3_5 = RMEMLow
parameters Rcell_0_0_3_6 = RMEMLow
parameters Rcell_0_0_3_7 = RMEMHigh
parameters Rcell_0_0_3_8 = RMEMLow
parameters Rcell_0_0_3_9 = RMEMLow
parameters Rcell_0_0_3_10 = RMEMHigh
parameters Rcell_0_0_3_11 = RMEMLow
parameters Rcell_0_0_3_12 = RMEMHigh
parameters Rcell_0_0_3_13 = RMEMHigh
parameters Rcell_0_0_3_14 = RMEMLow
parameters Rcell_0_0_3_15 = RMEMHigh
parameters Rcell_0_0_3_16 = RMEMHigh
parameters Rcell_0_0_3_17 = RMEMHigh
parameters Rcell_0_0_3_18 = RMEMHigh
parameters Rcell_0_0_3_19 = RMEMHigh
parameters Rcell_0_0_3_20 = RMEMHigh
parameters Rcell_0_0_3_21 = RMEMLow
parameters Rcell_0_0_3_22 = RMEMLow
parameters Rcell_0_0_3_23 = RMEMLow
parameters Rcell_0_0_3_24 = RMEMLow
parameters Rcell_0_0_3_25 = RMEMLow
parameters Rcell_0_0_3_26 = RMEMHigh
parameters Rcell_0_0_3_27 = RMEMHigh
parameters Rcell_0_0_3_28 = RMEMHigh
parameters Rcell_0_0_3_29 = RMEMHigh
parameters Rcell_0_0_3_30 = RMEMLow
parameters Rcell_0_0_3_31 = RMEMLow
parameters Rcell_0_0_3_32 = RMEMLow
parameters Rcell_0_0_3_33 = RMEMHigh
parameters Rcell_0_0_3_34 = RMEMLow
parameters Rcell_0_0_3_35 = RMEMHigh
parameters Rcell_0_0_3_36 = RMEMHigh
parameters Rcell_0_0_3_37 = RMEMHigh
parameters Rcell_0_0_3_38 = RMEMLow
parameters Rcell_0_0_3_39 = RMEMHigh
parameters Rcell_0_0_3_40 = RMEMLow
parameters Rcell_0_0_3_41 = RMEMLow
parameters Rcell_0_0_3_42 = RMEMHigh
parameters Rcell_0_0_3_43 = RMEMHigh
parameters Rcell_0_0_3_44 = RMEMLow
parameters Rcell_0_0_3_45 = RMEMHigh
parameters Rcell_0_0_3_46 = RMEMLow
parameters Rcell_0_0_3_47 = RMEMLow
parameters Rcell_0_0_3_48 = RMEMLow
parameters Rcell_0_0_3_49 = RMEMLow
parameters Rcell_0_0_3_50 = RMEMLow
parameters Rcell_0_0_3_51 = RMEMHigh
parameters Rcell_0_0_3_52 = RMEMLow
parameters Rcell_0_0_3_53 = RMEMHigh
parameters Rcell_0_0_3_54 = RMEMLow
parameters Rcell_0_0_3_55 = RMEMLow
parameters Rcell_0_0_3_56 = RMEMHigh
parameters Rcell_0_0_3_57 = RMEMLow
parameters Rcell_0_0_3_58 = RMEMLow
parameters Rcell_0_0_3_59 = RMEMHigh
parameters Rcell_0_0_3_60 = RMEMHigh
parameters Rcell_0_0_3_61 = RMEMHigh
parameters Rcell_0_0_3_62 = RMEMHigh
parameters Rcell_0_0_3_63 = RMEMLow
parameters Rcell_0_1_0_0 = RMEMHigh
parameters Rcell_0_1_0_1 = RMEMLow
parameters Rcell_0_1_0_2 = RMEMHigh
parameters Rcell_0_1_0_3 = RMEMLow
parameters Rcell_0_1_0_4 = RMEMLow
parameters Rcell_0_1_0_5 = RMEMHigh
parameters Rcell_0_1_0_6 = RMEMHigh
parameters Rcell_0_1_0_7 = RMEMLow
parameters Rcell_0_1_0_8 = RMEMLow
parameters Rcell_0_1_0_9 = RMEMHigh
parameters Rcell_0_1_0_10 = RMEMLow
parameters Rcell_0_1_0_11 = RMEMLow
parameters Rcell_0_1_0_12 = RMEMHigh
parameters Rcell_0_1_0_13 = RMEMHigh
parameters Rcell_0_1_0_14 = RMEMHigh
parameters Rcell_0_1_0_15 = RMEMHigh
parameters Rcell_0_1_0_16 = RMEMHigh
parameters Rcell_0_1_0_17 = RMEMHigh
parameters Rcell_0_1_0_18 = RMEMHigh
parameters Rcell_0_1_0_19 = RMEMHigh
parameters Rcell_0_1_0_20 = RMEMHigh
parameters Rcell_0_1_0_21 = RMEMLow
parameters Rcell_0_1_0_22 = RMEMHigh
parameters Rcell_0_1_0_23 = RMEMLow
parameters Rcell_0_1_0_24 = RMEMLow
parameters Rcell_0_1_0_25 = RMEMLow
parameters Rcell_0_1_0_26 = RMEMHigh
parameters Rcell_0_1_0_27 = RMEMLow
parameters Rcell_0_1_0_28 = RMEMLow
parameters Rcell_0_1_0_29 = RMEMHigh
parameters Rcell_0_1_0_30 = RMEMHigh
parameters Rcell_0_1_0_31 = RMEMLow
parameters Rcell_0_1_0_32 = RMEMLow
parameters Rcell_0_1_0_33 = RMEMLow
parameters Rcell_0_1_0_34 = RMEMLow
parameters Rcell_0_1_0_35 = RMEMHigh
parameters Rcell_0_1_0_36 = RMEMHigh
parameters Rcell_0_1_0_37 = RMEMHigh
parameters Rcell_0_1_0_38 = RMEMHigh
parameters Rcell_0_1_0_39 = RMEMLow
parameters Rcell_0_1_0_40 = RMEMHigh
parameters Rcell_0_1_0_41 = RMEMLow
parameters Rcell_0_1_0_42 = RMEMHigh
parameters Rcell_0_1_0_43 = RMEMHigh
parameters Rcell_0_1_0_44 = RMEMLow
parameters Rcell_0_1_0_45 = RMEMLow
parameters Rcell_0_1_0_46 = RMEMLow
parameters Rcell_0_1_0_47 = RMEMHigh
parameters Rcell_0_1_0_48 = RMEMLow
parameters Rcell_0_1_0_49 = RMEMLow
parameters Rcell_0_1_0_50 = RMEMLow
parameters Rcell_0_1_0_51 = RMEMLow
parameters Rcell_0_1_0_52 = RMEMLow
parameters Rcell_0_1_0_53 = RMEMHigh
parameters Rcell_0_1_0_54 = RMEMLow
parameters Rcell_0_1_0_55 = RMEMHigh
parameters Rcell_0_1_0_56 = RMEMLow
parameters Rcell_0_1_0_57 = RMEMHigh
parameters Rcell_0_1_0_58 = RMEMLow
parameters Rcell_0_1_0_59 = RMEMLow
parameters Rcell_0_1_0_60 = RMEMHigh
parameters Rcell_0_1_0_61 = RMEMHigh
parameters Rcell_0_1_0_62 = RMEMHigh
parameters Rcell_0_1_0_63 = RMEMLow
parameters Rcell_0_1_1_0 = RMEMHigh
parameters Rcell_0_1_1_1 = RMEMLow
parameters Rcell_0_1_1_2 = RMEMLow
parameters Rcell_0_1_1_3 = RMEMLow
parameters Rcell_0_1_1_4 = RMEMLow
parameters Rcell_0_1_1_5 = RMEMLow
parameters Rcell_0_1_1_6 = RMEMLow
parameters Rcell_0_1_1_7 = RMEMLow
parameters Rcell_0_1_1_8 = RMEMLow
parameters Rcell_0_1_1_9 = RMEMLow
parameters Rcell_0_1_1_10 = RMEMHigh
parameters Rcell_0_1_1_11 = RMEMHigh
parameters Rcell_0_1_1_12 = RMEMLow
parameters Rcell_0_1_1_13 = RMEMHigh
parameters Rcell_0_1_1_14 = RMEMHigh
parameters Rcell_0_1_1_15 = RMEMHigh
parameters Rcell_0_1_1_16 = RMEMLow
parameters Rcell_0_1_1_17 = RMEMLow
parameters Rcell_0_1_1_18 = RMEMHigh
parameters Rcell_0_1_1_19 = RMEMHigh
parameters Rcell_0_1_1_20 = RMEMLow
parameters Rcell_0_1_1_21 = RMEMLow
parameters Rcell_0_1_1_22 = RMEMHigh
parameters Rcell_0_1_1_23 = RMEMHigh
parameters Rcell_0_1_1_24 = RMEMHigh
parameters Rcell_0_1_1_25 = RMEMLow
parameters Rcell_0_1_1_26 = RMEMHigh
parameters Rcell_0_1_1_27 = RMEMHigh
parameters Rcell_0_1_1_28 = RMEMLow
parameters Rcell_0_1_1_29 = RMEMLow
parameters Rcell_0_1_1_30 = RMEMLow
parameters Rcell_0_1_1_31 = RMEMHigh
parameters Rcell_0_1_1_32 = RMEMLow
parameters Rcell_0_1_1_33 = RMEMLow
parameters Rcell_0_1_1_34 = RMEMHigh
parameters Rcell_0_1_1_35 = RMEMHigh
parameters Rcell_0_1_1_36 = RMEMLow
parameters Rcell_0_1_1_37 = RMEMLow
parameters Rcell_0_1_1_38 = RMEMHigh
parameters Rcell_0_1_1_39 = RMEMLow
parameters Rcell_0_1_1_40 = RMEMHigh
parameters Rcell_0_1_1_41 = RMEMLow
parameters Rcell_0_1_1_42 = RMEMHigh
parameters Rcell_0_1_1_43 = RMEMHigh
parameters Rcell_0_1_1_44 = RMEMHigh
parameters Rcell_0_1_1_45 = RMEMLow
parameters Rcell_0_1_1_46 = RMEMHigh
parameters Rcell_0_1_1_47 = RMEMHigh
parameters Rcell_0_1_1_48 = RMEMHigh
parameters Rcell_0_1_1_49 = RMEMLow
parameters Rcell_0_1_1_50 = RMEMHigh
parameters Rcell_0_1_1_51 = RMEMHigh
parameters Rcell_0_1_1_52 = RMEMLow
parameters Rcell_0_1_1_53 = RMEMHigh
parameters Rcell_0_1_1_54 = RMEMLow
parameters Rcell_0_1_1_55 = RMEMHigh
parameters Rcell_0_1_1_56 = RMEMLow
parameters Rcell_0_1_1_57 = RMEMLow
parameters Rcell_0_1_1_58 = RMEMLow
parameters Rcell_0_1_1_59 = RMEMHigh
parameters Rcell_0_1_1_60 = RMEMLow
parameters Rcell_0_1_1_61 = RMEMLow
parameters Rcell_0_1_1_62 = RMEMHigh
parameters Rcell_0_1_1_63 = RMEMHigh
parameters Rcell_0_1_2_0 = RMEMLow
parameters Rcell_0_1_2_1 = RMEMHigh
parameters Rcell_0_1_2_2 = RMEMHigh
parameters Rcell_0_1_2_3 = RMEMLow
parameters Rcell_0_1_2_4 = RMEMHigh
parameters Rcell_0_1_2_5 = RMEMLow
parameters Rcell_0_1_2_6 = RMEMHigh
parameters Rcell_0_1_2_7 = RMEMLow
parameters Rcell_0_1_2_8 = RMEMLow
parameters Rcell_0_1_2_9 = RMEMHigh
parameters Rcell_0_1_2_10 = RMEMLow
parameters Rcell_0_1_2_11 = RMEMHigh
parameters Rcell_0_1_2_12 = RMEMHigh
parameters Rcell_0_1_2_13 = RMEMLow
parameters Rcell_0_1_2_14 = RMEMLow
parameters Rcell_0_1_2_15 = RMEMHigh
parameters Rcell_0_1_2_16 = RMEMLow
parameters Rcell_0_1_2_17 = RMEMHigh
parameters Rcell_0_1_2_18 = RMEMLow
parameters Rcell_0_1_2_19 = RMEMLow
parameters Rcell_0_1_2_20 = RMEMLow
parameters Rcell_0_1_2_21 = RMEMHigh
parameters Rcell_0_1_2_22 = RMEMLow
parameters Rcell_0_1_2_23 = RMEMLow
parameters Rcell_0_1_2_24 = RMEMHigh
parameters Rcell_0_1_2_25 = RMEMHigh
parameters Rcell_0_1_2_26 = RMEMHigh
parameters Rcell_0_1_2_27 = RMEMLow
parameters Rcell_0_1_2_28 = RMEMLow
parameters Rcell_0_1_2_29 = RMEMHigh
parameters Rcell_0_1_2_30 = RMEMLow
parameters Rcell_0_1_2_31 = RMEMLow
parameters Rcell_0_1_2_32 = RMEMHigh
parameters Rcell_0_1_2_33 = RMEMHigh
parameters Rcell_0_1_2_34 = RMEMLow
parameters Rcell_0_1_2_35 = RMEMHigh
parameters Rcell_0_1_2_36 = RMEMLow
parameters Rcell_0_1_2_37 = RMEMHigh
parameters Rcell_0_1_2_38 = RMEMLow
parameters Rcell_0_1_2_39 = RMEMLow
parameters Rcell_0_1_2_40 = RMEMHigh
parameters Rcell_0_1_2_41 = RMEMLow
parameters Rcell_0_1_2_42 = RMEMLow
parameters Rcell_0_1_2_43 = RMEMHigh
parameters Rcell_0_1_2_44 = RMEMLow
parameters Rcell_0_1_2_45 = RMEMLow
parameters Rcell_0_1_2_46 = RMEMHigh
parameters Rcell_0_1_2_47 = RMEMLow
parameters Rcell_0_1_2_48 = RMEMLow
parameters Rcell_0_1_2_49 = RMEMLow
parameters Rcell_0_1_2_50 = RMEMLow
parameters Rcell_0_1_2_51 = RMEMLow
parameters Rcell_0_1_2_52 = RMEMLow
parameters Rcell_0_1_2_53 = RMEMHigh
parameters Rcell_0_1_2_54 = RMEMHigh
parameters Rcell_0_1_2_55 = RMEMLow
parameters Rcell_0_1_2_56 = RMEMLow
parameters Rcell_0_1_2_57 = RMEMHigh
parameters Rcell_0_1_2_58 = RMEMHigh
parameters Rcell_0_1_2_59 = RMEMHigh
parameters Rcell_0_1_2_60 = RMEMHigh
parameters Rcell_0_1_2_61 = RMEMLow
parameters Rcell_0_1_2_62 = RMEMHigh
parameters Rcell_0_1_2_63 = RMEMLow
parameters Rcell_0_1_3_0 = RMEMLow
parameters Rcell_0_1_3_1 = RMEMLow
parameters Rcell_0_1_3_2 = RMEMHigh
parameters Rcell_0_1_3_3 = RMEMLow
parameters Rcell_0_1_3_4 = RMEMHigh
parameters Rcell_0_1_3_5 = RMEMHigh
parameters Rcell_0_1_3_6 = RMEMLow
parameters Rcell_0_1_3_7 = RMEMHigh
parameters Rcell_0_1_3_8 = RMEMHigh
parameters Rcell_0_1_3_9 = RMEMHigh
parameters Rcell_0_1_3_10 = RMEMLow
parameters Rcell_0_1_3_11 = RMEMLow
parameters Rcell_0_1_3_12 = RMEMHigh
parameters Rcell_0_1_3_13 = RMEMHigh
parameters Rcell_0_1_3_14 = RMEMLow
parameters Rcell_0_1_3_15 = RMEMHigh
parameters Rcell_0_1_3_16 = RMEMLow
parameters Rcell_0_1_3_17 = RMEMHigh
parameters Rcell_0_1_3_18 = RMEMLow
parameters Rcell_0_1_3_19 = RMEMHigh
parameters Rcell_0_1_3_20 = RMEMHigh
parameters Rcell_0_1_3_21 = RMEMLow
parameters Rcell_0_1_3_22 = RMEMLow
parameters Rcell_0_1_3_23 = RMEMLow
parameters Rcell_0_1_3_24 = RMEMHigh
parameters Rcell_0_1_3_25 = RMEMHigh
parameters Rcell_0_1_3_26 = RMEMHigh
parameters Rcell_0_1_3_27 = RMEMHigh
parameters Rcell_0_1_3_28 = RMEMLow
parameters Rcell_0_1_3_29 = RMEMHigh
parameters Rcell_0_1_3_30 = RMEMHigh
parameters Rcell_0_1_3_31 = RMEMLow
parameters Rcell_0_1_3_32 = RMEMHigh
parameters Rcell_0_1_3_33 = RMEMLow
parameters Rcell_0_1_3_34 = RMEMLow
parameters Rcell_0_1_3_35 = RMEMLow
parameters Rcell_0_1_3_36 = RMEMHigh
parameters Rcell_0_1_3_37 = RMEMHigh
parameters Rcell_0_1_3_38 = RMEMHigh
parameters Rcell_0_1_3_39 = RMEMLow
parameters Rcell_0_1_3_40 = RMEMLow
parameters Rcell_0_1_3_41 = RMEMLow
parameters Rcell_0_1_3_42 = RMEMLow
parameters Rcell_0_1_3_43 = RMEMHigh
parameters Rcell_0_1_3_44 = RMEMLow
parameters Rcell_0_1_3_45 = RMEMLow
parameters Rcell_0_1_3_46 = RMEMHigh
parameters Rcell_0_1_3_47 = RMEMLow
parameters Rcell_0_1_3_48 = RMEMLow
parameters Rcell_0_1_3_49 = RMEMHigh
parameters Rcell_0_1_3_50 = RMEMHigh
parameters Rcell_0_1_3_51 = RMEMHigh
parameters Rcell_0_1_3_52 = RMEMHigh
parameters Rcell_0_1_3_53 = RMEMHigh
parameters Rcell_0_1_3_54 = RMEMHigh
parameters Rcell_0_1_3_55 = RMEMLow
parameters Rcell_0_1_3_56 = RMEMLow
parameters Rcell_0_1_3_57 = RMEMHigh
parameters Rcell_0_1_3_58 = RMEMHigh
parameters Rcell_0_1_3_59 = RMEMHigh
parameters Rcell_0_1_3_60 = RMEMHigh
parameters Rcell_0_1_3_61 = RMEMLow
parameters Rcell_0_1_3_62 = RMEMLow
parameters Rcell_0_1_3_63 = RMEMLow

parameters Rref_0 = RMEMHigh
parameters Rref_2 = RMEMHigh
parameters Rref_4 = RMEMHigh
parameters Rref_6 = RMEMHigh
parameters Rref_8 = RMEMHigh
parameters Rref_10 = RMEMHigh
parameters Rref_12 = RMEMHigh
parameters Rref_14 = RMEMHigh
parameters Rref_16 = RMEMHigh
parameters Rref_18 = RMEMHigh
parameters Rref_20 = RMEMHigh
parameters Rref_22 = RMEMHigh
parameters Rref_24 = RMEMHigh
parameters Rref_26 = RMEMHigh
parameters Rref_28 = RMEMHigh
parameters Rref_30 = RMEMHigh
parameters Rref_32 = RMEMHigh
parameters Rref_34 = RMEMHigh
parameters Rref_36 = RMEMHigh
parameters Rref_38 = RMEMHigh
parameters Rref_40 = RMEMHigh
parameters Rref_42 = RMEMHigh
parameters Rref_44 = RMEMHigh
parameters Rref_46 = RMEMHigh
parameters Rref_48 = RMEMHigh
parameters Rref_50 = RMEMHigh
parameters Rref_52 = RMEMHigh
parameters Rref_54 = RMEMHigh
parameters Rref_56 = RMEMHigh
parameters Rref_58 = RMEMHigh
parameters Rref_60 = RMEMHigh
parameters Rref_62 = RMEMHigh
parameters Rref_1 = RMEMLow
parameters Rref_3 = RMEMLow
parameters Rref_5 = RMEMLow
parameters Rref_7 = RMEMLow
parameters Rref_9 = RMEMLow
parameters Rref_11 = RMEMLow
parameters Rref_13 = RMEMLow
parameters Rref_15 = RMEMLow
parameters Rref_17 = RMEMLow
parameters Rref_19 = RMEMLow
parameters Rref_21 = RMEMLow
parameters Rref_23 = RMEMLow
parameters Rref_25 = RMEMLow
parameters Rref_27 = RMEMLow
parameters Rref_29 = RMEMLow
parameters Rref_31 = RMEMLow
parameters Rref_33 = RMEMLow
parameters Rref_35 = RMEMLow
parameters Rref_37 = RMEMLow
parameters Rref_39 = RMEMLow
parameters Rref_41 = RMEMLow
parameters Rref_43 = RMEMLow
parameters Rref_45 = RMEMLow
parameters Rref_47 = RMEMLow
parameters Rref_49 = RMEMLow
parameters Rref_51 = RMEMLow
parameters Rref_53 = RMEMLow
parameters Rref_55 = RMEMLow
parameters Rref_57 = RMEMLow
parameters Rref_59 = RMEMLow
parameters Rref_61 = RMEMLow
parameters Rref_63 = RMEMLow

parameters waveEnGB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53710000000002e-06 1 1.54100000000002e-06 1 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveEnLB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29905000000003e-06 0 2.30300000000003e-06 0 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68305000000004e-06 0 2.68700000000004e-06 0 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87505000000004e-06 0 2.87900000000004e-06 0 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97105000000004e-06 0 2.97500000000004e-06 0 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01905000000004e-06 0 3.02300000000004e-06 0 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04305000000004e-06 0 3.04700000000004e-06 0 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05505000000004e-06 0 3.05900000000004e-06 0 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06105000000004e-06 0 3.06500000000004e-06 0 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06705000000004e-06 0 3.07100000000004e-06 0 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveEnLB_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63049999999997e-07 0 7.66999999999997e-07 0 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.14705e-06 0 1.151e-06 0 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33905000000001e-06 0 1.34300000000001e-06 0 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43505000000001e-06 0 1.43900000000001e-06 0 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48305000000002e-06 0 1.48700000000002e-06 0 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50705000000002e-06 0 1.51100000000002e-06 0 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51905000000002e-06 0 1.52300000000002e-06 0 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52505000000002e-06 0 1.52900000000002e-06 0 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53105000000002e-06 0 1.53500000000002e-06 0 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53710000000002e-06 1 1.54100000000002e-06 1 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveBLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.14705e-06 0 1.151e-06 0 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68305000000004e-06 0 2.68700000000004e-06 0 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveBLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63049999999997e-07 0 7.66999999999997e-07 0 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29905000000003e-06 0 2.30300000000003e-06 0 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveWLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52505000000002e-06 0 1.52900000000002e-06 0 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06105000000004e-06 0 3.06500000000004e-06 0 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveWLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51905000000002e-06 0 1.52300000000002e-06 0 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05505000000004e-06 0 3.05900000000004e-06 0 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveWLstart_2=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50705000000002e-06 0 1.51100000000002e-06 0 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04305000000004e-06 0 3.04700000000004e-06 0 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveWLstart_3=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48305000000002e-06 0 1.48700000000002e-06 0 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01905000000004e-06 0 3.02300000000004e-06 0 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveWLstart_4=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43505000000001e-06 0 1.43900000000001e-06 0 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97105000000004e-06 0 2.97500000000004e-06 0 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
parameters waveWLstart_5=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33905000000001e-06 0 1.34300000000001e-06 0 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87505000000004e-06 0 2.87900000000004e-06 0 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07200000000004e-06 0 3.07205000000004e-06 0 3.07800000000004e-06 0 3.07805000000004e-06 0 3.08400000000004e-06 0 3.08405000000004e-06 0 3.09000000000004e-06 0 3.09005000000004e-06 0 3.09600000000004e-06 0 3.09605000000004e-06 0 3.10200000000004e-06 0 3.10205000000004e-06 0 3.10800000000004e-06 0 3.10805000000004e-06 0 3.11400000000004e-06 0 3.11405000000004e-06 0 3.12000000000004e-06 0 3.12005000000004e-06 0 3.12600000000004e-06 0 3.12605000000004e-06 0 3.13200000000004e-06 0 3.13205000000004e-06 0 3.13800000000004e-06 0 3.13805000000004e-06 0 3.14400000000004e-06 0 3.14405000000004e-06 0 3.15000000000004e-06 0 3.15005000000004e-06 0 3.15600000000004e-06 0 3.15605000000004e-06 0 3.16200000000004e-06 0 3.16205000000004e-06 0 3.16800000000004e-06 0 3.16805000000004e-06 0 3.17400000000004e-06 0 3.17405000000004e-06 0 3.18000000000004e-06 0 3.18005000000004e-06 0 3.18600000000004e-06 0 3.18605000000004e-06 0 3.19200000000004e-06 0 3.19205000000004e-06 0 3.19800000000004e-06 0 3.19805000000004e-06 0 3.20400000000004e-06 0 3.20405000000004e-06 0 3.21000000000004e-06 0 3.21005000000004e-06 0 3.21600000000004e-06 0 3.21605000000004e-06 0 3.22200000000004e-06 0 3.22205000000004e-06 0 3.22800000000004e-06 0 3.22805000000004e-06 0 3.23400000000004e-06 0 3.23405000000004e-06 0 3.24000000000004e-06 0 3.24005000000004e-06 0 3.24600000000004e-06 0 3.24605000000004e-06 0 3.25200000000004e-06 0 3.25205000000004e-06 0 3.25800000000004e-06 0 3.25805000000004e-06 0 3.26400000000004e-06 0 3.26405000000004e-06 0 3.27000000000004e-06 0 3.27005000000004e-06 0 3.27600000000004e-06 0 3.27605000000004e-06 0 3.28200000000004e-06 0 3.28205000000004e-06 0 3.28800000000004e-06 0 3.28805000000004e-06 0 3.29400000000004e-06 0 3.29405000000004e-06 0 3.30000000000004e-06 0 3.30005000000004e-06 0 3.30600000000004e-06 0 3.30605000000004e-06 0 3.31200000000004e-06 0 3.31205000000004e-06 0 3.31800000000004e-06 0 3.31805000000004e-06 0 3.32400000000004e-06 0 3.32405000000004e-06 0 3.33000000000004e-06 0 3.33005000000004e-06 0 3.33600000000004e-06 0 3.33605000000004e-06 0 3.34200000000004e-06 0 3.34205000000004e-06 0 3.34800000000004e-06 0 3.34805000000004e-06 0 3.35400000000004e-06 0 3.35405000000004e-06 0 3.36000000000004e-06 0 3.36005000000004e-06 0 3.36600000000004e-06 0 3.36605000000004e-06 0 3.37200000000004e-06 0 3.37205000000004e-06 0 3.37800000000004e-06 0 3.37805000000004e-06 0 3.38400000000004e-06 0 3.38405000000004e-06 0 3.39000000000004e-06 0 3.39005000000004e-06 0 3.39600000000004e-06 0 3.39605000000004e-06 0 3.40200000000004e-06 0 3.40205000000004e-06 0 3.40800000000004e-06 0 3.40805000000004e-06 0 3.41400000000004e-06 0 3.41405000000004e-06 0 3.42000000000004e-06 0 3.42005000000004e-06 0 3.42600000000004e-06 0 3.42605000000004e-06 0 3.43200000000004e-06 0 3.43205000000004e-06 0 3.43800000000004e-06 0 3.43805000000004e-06 0 3.44400000000004e-06 0 3.44405000000004e-06 0 3.45000000000004e-06 0 3.45005000000004e-06 0 3.45600000000004e-06 0 3.45605000000004e-06 0 3.46200000000004e-06 0 3.46205000000004e-06 0 3.46800000000004e-06 0 3.46805000000004e-06 0 3.47400000000004e-06 0 3.47405000000004e-06 0 3.48000000000004e-06 0 3.48005000000004e-06 0 3.48600000000004e-06 0 3.48605000000004e-06 0 3.49200000000004e-06 0 3.49205000000004e-06 0 3.49800000000004e-06 0 3.49805000000004e-06 0 3.50400000000004e-06 0 3.50405000000004e-06 0 3.51000000000004e-06 0 3.51005000000004e-06 0 3.51600000000004e-06 0 3.51605000000004e-06 0 3.52200000000004e-06 0 3.52205000000004e-06 0 3.52800000000004e-06 0 3.52805000000004e-06 0 3.53400000000004e-06 0 3.53405000000004e-06 0 3.54000000000004e-06 0 3.54005000000004e-06 0 3.54600000000004e-06 0 3.54605000000004e-06 0 3.55200000000004e-06 0 3.55205000000004e-06 0 3.55800000000004e-06 0 3.55805000000004e-06 0 3.56400000000004e-06 0 3.56405000000004e-06 0 3.57000000000004e-06 0 3.57005000000004e-06 0 3.57600000000004e-06 0 3.57605000000004e-06 0 3.58200000000004e-06 0 3.58205000000004e-06 0 3.58800000000004e-06 0 3.58805000000004e-06 0 3.59400000000004e-06 0 3.59405000000004e-06 0 3.60000000000004e-06 0 3.60005000000004e-06 0 3.60600000000004e-06 0 3.60605000000004e-06 0 3.61200000000004e-06 0 3.61205000000004e-06 0 3.61800000000004e-06 0 3.61805000000004e-06 0 3.62400000000004e-06 0 3.62405000000004e-06 0 3.63000000000004e-06 0 3.63005000000004e-06 0 3.63600000000004e-06 0 3.63605000000004e-06 0 3.64200000000004e-06 0 3.64205000000004e-06 0 3.64800000000004e-06 0 3.64805000000004e-06 0 3.65400000000004e-06 0 3.65405000000004e-06 0 3.66000000000004e-06 0 3.66005000000004e-06 0 3.66600000000004e-06 0 3.66605000000004e-06 0 3.67200000000004e-06 0 3.67205000000004e-06 0 3.67800000000004e-06 0 3.67805000000004e-06 0 3.68400000000004e-06 0 3.68405000000004e-06 0 3.69000000000004e-06 0 3.69005000000004e-06 0 3.69600000000004e-06 0 3.69605000000004e-06 0 3.70200000000004e-06 0 3.70205000000004e-06 0 3.70800000000004e-06 0 3.70805000000004e-06 0 3.71400000000004e-06 0 3.71405000000004e-06 0 3.72000000000004e-06 0 3.72005000000004e-06 0 3.72600000000004e-06 0 3.72605000000004e-06 0 3.73200000000004e-06 0 3.73205000000004e-06 0 3.73800000000004e-06 0 3.73805000000004e-06 0 3.74400000000004e-06 0 3.74405000000004e-06 0 3.75000000000004e-06 0 3.75005000000004e-06 0 3.75600000000004e-06 0 3.75605000000004e-06 0 3.76200000000004e-06 0 3.76205000000004e-06 0 3.76800000000004e-06 0 3.76805000000004e-06 0 3.77400000000004e-06 0 3.77405000000004e-06 0 3.78000000000004e-06 0 3.78005000000004e-06 0 3.78600000000004e-06 0 3.78605000000004e-06 0 3.79200000000004e-06 0 3.79205000000004e-06 0 3.79800000000004e-06 0 3.79805000000004e-06 0 3.80400000000004e-06 0 3.80405000000004e-06 0 3.81000000000004e-06 0 3.81005000000004e-06 0 3.81600000000004e-06 0 3.81605000000004e-06 0 3.82200000000004e-06 0 3.82205000000004e-06 0 3.82800000000004e-06 0 3.82805000000004e-06 0 3.83400000000004e-06 0 3.83405000000004e-06 0 3.84000000000004e-06 0 3.84005000000004e-06 0 3.84600000000004e-06 0 3.84605000000004e-06 0 3.85200000000004e-06 0 3.85205000000004e-06 0 3.85800000000004e-06 0 3.85805000000004e-06 0 3.86400000000004e-06 0 3.86405000000004e-06 0 3.87000000000004e-06 0 3.87005000000004e-06 0 3.87600000000004e-06 0 3.87605000000004e-06 0 3.88200000000004e-06 0 3.88205000000004e-06 0 3.88800000000004e-06 0 3.88805000000004e-06 0 3.89400000000004e-06 0 3.89405000000004e-06 0 3.90000000000004e-06 0 3.90005000000004e-06 0 3.90600000000004e-06 0 3.90605000000004e-06 0 3.91200000000003e-06 0 3.91205000000003e-06 0 3.91800000000003e-06 0 3.91805000000003e-06 0 3.92400000000003e-06 0 3.92405000000003e-06 0 3.93000000000003e-06 0 3.93005000000003e-06 0 3.93600000000003e-06 0 3.93605000000003e-06 0 3.94200000000003e-06 0 3.94205000000003e-06 0 3.94800000000003e-06 0 3.94805000000003e-06 0 3.95400000000003e-06 0 3.95405000000003e-06 0 3.96000000000003e-06 0 3.96005000000003e-06 0 3.96600000000003e-06 0 3.96605000000003e-06 0 3.97200000000003e-06 0 3.97205000000003e-06 0 3.97800000000003e-06 0 3.97805000000003e-06 0 3.98400000000003e-06 0 3.98405000000003e-06 0 3.99000000000003e-06 0 3.99005000000003e-06 0 3.99600000000003e-06 0 3.99605000000003e-06 0 4.00200000000003e-06 0 4.00205000000003e-06 0 4.00800000000003e-06 0 4.00805000000003e-06 0 4.01400000000003e-06 0 4.01405000000003e-06 0 4.02000000000003e-06 0 4.02005000000003e-06 0 4.02600000000003e-06 0 4.02605000000003e-06 0 4.03200000000003e-06 0 4.03205000000003e-06 0 4.03800000000003e-06 0 4.03805000000003e-06 0 4.04400000000003e-06 0 4.04405000000003e-06 0 4.05000000000003e-06 0 4.05005000000003e-06 0 4.05600000000003e-06 0 4.05605000000003e-06 0 4.06200000000002e-06 0 4.06205000000002e-06 0 4.06800000000002e-06 0 4.06805000000002e-06 0 4.07400000000002e-06 0 4.07405000000002e-06 0 4.08000000000002e-06 0 4.08005000000002e-06 0 4.08600000000002e-06 0 4.08605000000002e-06 0 4.09200000000002e-06 0 4.09205000000002e-06 0 4.09800000000002e-06 0 4.09805000000002e-06 0 4.10400000000002e-06 0 4.10405000000002e-06 0 4.11000000000002e-06 0 4.11005000000002e-06 0 4.11600000000002e-06 0 4.11605000000002e-06 0 4.12200000000002e-06 0 4.12205000000002e-06 0 4.12800000000002e-06 0 4.12805000000002e-06 0 4.13400000000002e-06 0 4.13405000000002e-06 0 4.14000000000002e-06 0 4.14005000000002e-06 0 4.14600000000002e-06 0 4.14605000000002e-06 0 4.15200000000002e-06 0 4.15205000000002e-06 0 4.15800000000002e-06 0 4.15805000000002e-06 0 4.16400000000002e-06 0 4.16405000000002e-06 0 4.17000000000002e-06 0 4.17005000000002e-06 0 4.17600000000002e-06 0 4.17605000000002e-06 0 4.18200000000002e-06 0 4.18205000000002e-06 0 4.18800000000002e-06 0 4.18805000000002e-06 0 4.19400000000002e-06 0 4.19405000000002e-06 0 4.20000000000002e-06 0 4.20005000000002e-06 0 4.20600000000002e-06 0 4.20605000000002e-06 0 4.21200000000001e-06 0 4.21205000000002e-06 0 4.21800000000001e-06 0 4.21805000000001e-06 0 4.22400000000001e-06 0 4.22405000000001e-06 0 4.23000000000001e-06 0 4.23005000000001e-06 0 4.23600000000001e-06 0 4.23605000000001e-06 0 4.24200000000001e-06 0 4.24205000000001e-06 0 4.24800000000001e-06 0 4.24805000000001e-06 0 4.25400000000001e-06 0 4.25405000000001e-06 0 4.26000000000001e-06 0 4.26005000000001e-06 0 4.26600000000001e-06 0 4.26605000000001e-06 0 4.27200000000001e-06 0 4.27205000000001e-06 0 4.27800000000001e-06 0 4.27805000000001e-06 0 4.28400000000001e-06 0 4.28405000000001e-06 0 4.29000000000001e-06 0 4.29005000000001e-06 0 4.29600000000001e-06 0 4.29605000000001e-06 0 4.30200000000001e-06 0 4.30205000000001e-06 0 4.30800000000001e-06 0 4.30805000000001e-06 0 4.31400000000001e-06 0 4.31405000000001e-06 0 4.32000000000001e-06 0 4.32005000000001e-06 0 4.32600000000001e-06 0 4.32605000000001e-06 0 4.33200000000001e-06 0 4.33205000000001e-06 0 4.33800000000001e-06 0 4.33805000000001e-06 0 4.34400000000001e-06 0 4.34405000000001e-06 0 4.35000000000001e-06 0 4.35005000000001e-06 0 4.35600000000001e-06 0 4.35605000000001e-06 0 4.362e-06 0 4.36205000000001e-06 0 4.368e-06 0 4.36805e-06 0 4.374e-06 0 4.37405e-06 0 4.38e-06 0 4.38005e-06 0 4.386e-06 0 4.38605e-06 0 4.392e-06 0 4.39205e-06 0 4.398e-06 0 4.39805e-06 0 4.404e-06 0 4.40405e-06 0 4.41e-06 0 4.41005e-06 0 4.416e-06 0 4.41605e-06 0 4.422e-06 0 4.42205e-06 0 4.428e-06 0 4.42805e-06 0 4.434e-06 0 4.43405e-06 0 4.44e-06 0 4.44005e-06 0 4.446e-06 0 4.44605e-06 0 4.452e-06 0 4.45205e-06 0 4.458e-06 0 4.45805e-06 0 4.464e-06 0 4.46405e-06 0 4.47e-06 0 4.47005e-06 0 4.476e-06 0 4.47605e-06 0 4.482e-06 0 4.48205e-06 0 4.488e-06 0 4.48805e-06 0 4.494e-06 0 4.49405e-06 0 4.5e-06 0 4.50005e-06 0 4.506e-06 0 4.50605e-06 0 4.512e-06 0 4.51205e-06 0 4.51799999999999e-06 0 4.51804999999999e-06 0 4.52399999999999e-06 0 4.52404999999999e-06 0 4.52999999999999e-06 0 4.53004999999999e-06 0 4.53599999999999e-06 0 4.53604999999999e-06 0 4.54199999999999e-06 0 4.54204999999999e-06 0 4.54799999999999e-06 0 4.54804999999999e-06 0 4.55399999999999e-06 0 4.55404999999999e-06 0 4.55999999999999e-06 0 4.56004999999999e-06 0 4.56599999999999e-06 0 4.56604999999999e-06 0 4.57199999999999e-06 0 4.57204999999999e-06 0 4.57799999999999e-06 0 4.57804999999999e-06 0 4.58399999999999e-06 0 4.58404999999999e-06 0 4.58999999999999e-06 0 4.59004999999999e-06 0 4.59599999999999e-06 0 4.59604999999999e-06 0 4.60199999999999e-06 0 4.60204999999999e-06 0 4.60799999999999e-06 0 4.60804999999999e-06 0 4.61399999999999e-06 0 4.61404999999999e-06 0 4.61999999999999e-06 0 4.62004999999999e-06 0 4.62599999999999e-06 0 4.62604999999999e-06 0 4.63199999999999e-06 0 4.63204999999999e-06 0 4.63799999999999e-06 0 4.63804999999999e-06 0 4.64399999999999e-06 0 4.64404999999999e-06 0 4.64999999999999e-06 0 4.65004999999999e-06 0 4.65599999999999e-06 0 4.65604999999999e-06 0 4.66199999999999e-06 0 4.66204999999999e-06 0 4.66799999999998e-06 0 4.66804999999998e-06 0 4.67399999999998e-06 0 4.67404999999998e-06 0 4.67999999999998e-06 0 4.68004999999998e-06 0 4.68599999999998e-06 0 4.68604999999998e-06 0 4.69199999999998e-06 0 4.69204999999998e-06 0 4.69799999999998e-06 0 4.69804999999998e-06 0 4.70399999999998e-06 0 4.70404999999998e-06 0 4.70999999999998e-06 0 4.71004999999998e-06 0 4.71599999999998e-06 0 4.71604999999998e-06 0 4.72199999999998e-06 0 4.72204999999998e-06 0 4.72799999999998e-06 0 4.72804999999998e-06 0 4.73399999999998e-06 0 4.73404999999998e-06 0 4.73999999999998e-06 0 4.74004999999998e-06 0 4.74599999999998e-06 0 4.74604999999998e-06 0 4.75199999999998e-06 0 4.75204999999998e-06 0 4.75799999999998e-06 0 4.75804999999998e-06 0 4.76399999999998e-06 0 4.76404999999998e-06 0 4.76999999999998e-06 0 4.77004999999998e-06 0 4.77599999999998e-06 0 4.77604999999998e-06 0 4.78199999999998e-06 0 4.78204999999998e-06 0 4.78799999999998e-06 0 4.78804999999998e-06 0 4.79399999999998e-06 0 4.79404999999998e-06 0 4.79999999999998e-06 0 4.80004999999998e-06 0 4.80599999999998e-06 0 4.80604999999998e-06 0 4.81199999999998e-06 0 4.81204999999998e-06 0 4.81799999999997e-06 0 4.81804999999997e-06 0 4.82399999999997e-06 0 4.82404999999997e-06 0 4.82999999999997e-06 0 4.83004999999997e-06 0 4.83599999999997e-06 0 4.83604999999997e-06 0 4.84199999999997e-06 0 4.84204999999997e-06 0 4.84799999999997e-06 0 4.84804999999997e-06 0 4.85399999999997e-06 0 4.85404999999997e-06 0 4.85999999999997e-06 0 4.86004999999997e-06 0 4.86599999999997e-06 0 4.86604999999997e-06 0 4.87199999999997e-06 0 4.87204999999997e-06 0 4.87799999999997e-06 0 4.87804999999997e-06 0 4.88399999999997e-06 0 4.88404999999997e-06 0 4.88999999999997e-06 0 4.89004999999997e-06 0 4.89599999999997e-06 0 4.89604999999997e-06 0 4.90199999999997e-06 0 4.90204999999997e-06 0 4.90799999999997e-06 0 4.90804999999997e-06 0 4.91399999999997e-06 0 4.91404999999997e-06 0 4.91999999999997e-06 0 4.92004999999997e-06 0 4.92599999999997e-06 0 4.92604999999997e-06 0 4.93199999999997e-06 0 4.93204999999997e-06 0 4.93799999999997e-06 0 4.93804999999997e-06 0 4.94399999999997e-06 0 4.94404999999997e-06 0 4.94999999999997e-06 0 4.95004999999997e-06 0 4.95599999999997e-06 0 4.95604999999997e-06 0 4.96199999999997e-06 0 4.96204999999997e-06 0 4.96799999999996e-06 0 4.96804999999997e-06 0 4.97399999999996e-06 0 4.97404999999996e-06 0 4.97999999999996e-06 0 4.98004999999996e-06 0 4.98599999999996e-06 0 4.98604999999996e-06 0 4.99199999999996e-06 0 4.99204999999996e-06 0 4.99799999999996e-06 0 4.99804999999996e-06 0 5.00399999999996e-06 0 5.00404999999996e-06 0 5.00999999999996e-06 0 5.01004999999996e-06 0 5.01599999999996e-06 0 5.01604999999996e-06 0 5.02199999999996e-06 0 5.02204999999996e-06 0 5.02799999999996e-06 0 5.02804999999996e-06 0 5.03399999999996e-06 0 5.03404999999996e-06 0 5.03999999999996e-06 0 5.04004999999996e-06 0 5.04599999999996e-06 0 5.04604999999996e-06 0 5.05199999999996e-06 0 5.05204999999996e-06 0 5.05799999999996e-06 0 5.05804999999996e-06 0 5.06399999999996e-06 0 5.06404999999996e-06 0 5.06999999999996e-06 0 5.07004999999996e-06 0 5.07599999999996e-06 0 5.07604999999996e-06 0 5.08199999999996e-06 0 5.08204999999996e-06 0 5.08799999999996e-06 0 5.08804999999996e-06 0 5.09399999999996e-06 0 5.09404999999996e-06 0 5.09999999999996e-06 0 5.10004999999996e-06 0 5.10599999999996e-06 0 5.10604999999996e-06 0 5.11199999999996e-06 0 5.11204999999996e-06 0 5.11799999999996e-06 0 5.11804999999996e-06 0 5.12399999999995e-06 0 5.12404999999995e-06 0 5.12999999999995e-06 0 5.13004999999995e-06 0 5.13599999999995e-06 0 5.13604999999995e-06 0 5.14199999999995e-06 0 5.14204999999995e-06 0 5.14799999999995e-06 0 5.14804999999995e-06 0 5.15399999999995e-06 0 5.15404999999995e-06 0 5.15999999999995e-06 0 5.16004999999995e-06 0 5.16599999999995e-06 0 5.16604999999995e-06 0 5.17199999999995e-06 0 5.17204999999995e-06 0 5.17799999999995e-06 0 5.17804999999995e-06 0 5.18399999999995e-06 0 5.18404999999995e-06 0 5.18999999999995e-06 0 5.19004999999995e-06 0 5.19599999999995e-06 0 5.19604999999995e-06 0 5.20199999999995e-06 0 5.20204999999995e-06 0 5.20799999999995e-06 0 5.20804999999995e-06 0 5.21399999999995e-06 0 5.21404999999995e-06 0 5.21999999999995e-06 0 5.22004999999995e-06 0 5.22599999999995e-06 0 5.22604999999995e-06 0 5.23199999999995e-06 0 5.23204999999995e-06 0 5.23799999999995e-06 0 5.23804999999995e-06 0 5.24399999999995e-06 0 5.24404999999995e-06 0 5.24999999999995e-06 0 5.25004999999995e-06 0 5.25599999999995e-06 0 5.25604999999995e-06 0 5.26199999999995e-06 0 5.26204999999995e-06 0 5.26799999999995e-06 0 5.26804999999995e-06 0 5.27399999999994e-06 0 5.27404999999994e-06 0 5.27999999999994e-06 0 5.28004999999994e-06 0 5.28599999999994e-06 0 5.28604999999994e-06 0 5.29199999999994e-06 0 5.29204999999994e-06 0 5.29799999999994e-06 0 5.29804999999994e-06 0 5.30399999999994e-06 0 5.30404999999994e-06 0 5.30999999999994e-06 0 5.31004999999994e-06 0 5.31599999999994e-06 0 5.31604999999994e-06 0 5.32199999999994e-06 0 5.32204999999994e-06 0 5.32799999999994e-06 0 5.32804999999994e-06 0 5.33399999999994e-06 0 5.33404999999994e-06 0 5.33999999999994e-06 0 5.34004999999994e-06 0 5.34599999999994e-06 0 5.34604999999994e-06 0 5.35199999999994e-06 0 5.35204999999994e-06 0 5.35799999999994e-06 0 5.35804999999994e-06 0 5.36399999999994e-06 0 5.36404999999994e-06 0 5.36999999999994e-06 0 5.37004999999994e-06 0 5.37599999999994e-06 0 5.37604999999994e-06 0 5.38199999999994e-06 0 5.38204999999994e-06 0 5.38799999999994e-06 0 5.38804999999994e-06 0 5.39399999999994e-06 0 5.39404999999994e-06 0 5.39999999999994e-06 0 5.40004999999994e-06 0 5.40599999999994e-06 0 5.40604999999994e-06 0 5.41199999999994e-06 0 5.41204999999994e-06 0 5.41799999999994e-06 0 5.41804999999994e-06 0 5.42399999999993e-06 0 5.42404999999993e-06 0 5.42999999999993e-06 0 5.43004999999993e-06 0 5.43599999999993e-06 0 5.43604999999993e-06 0 5.44199999999993e-06 0 5.44204999999993e-06 0 5.44799999999993e-06 0 5.44804999999993e-06 0 5.45399999999993e-06 0 5.45404999999993e-06 0 5.45999999999993e-06 0 5.46004999999993e-06 0 5.46599999999993e-06 0 5.46604999999993e-06 0 5.47199999999993e-06 0 5.47204999999993e-06 0 5.47799999999993e-06 0 5.47804999999993e-06 0 5.48399999999993e-06 0 5.48404999999993e-06 0 5.48999999999993e-06 0 5.49004999999993e-06 0 5.49599999999993e-06 0 5.49604999999993e-06 0 5.50199999999993e-06 0 5.50204999999993e-06 0 5.50799999999993e-06 0 5.50804999999993e-06 0 5.51399999999993e-06 0 5.51404999999993e-06 0 5.51999999999993e-06 0 5.52004999999993e-06 0 5.52599999999993e-06 0 5.52604999999993e-06 0 5.53199999999993e-06 0 5.53204999999993e-06 0 5.53799999999993e-06 0 5.53804999999993e-06 0 5.54399999999993e-06 0 5.54404999999993e-06 0 5.54999999999993e-06 0 5.55004999999993e-06 0 5.55599999999993e-06 0 5.55604999999993e-06 0 5.56199999999993e-06 0 5.56204999999993e-06 0 5.56799999999993e-06 0 5.56804999999993e-06 0 5.57399999999992e-06 0 5.57404999999993e-06 0 5.57999999999992e-06 0 5.58004999999992e-06 0 5.58599999999992e-06 0 5.58604999999992e-06 0 5.59199999999992e-06 0 5.59204999999992e-06 0 5.59799999999992e-06 0 5.59804999999992e-06 0 5.60399999999992e-06 0 5.60404999999992e-06 0 5.60999999999992e-06 0 5.61004999999992e-06 0 5.61599999999992e-06 0 5.61604999999992e-06 0 5.62199999999992e-06 0 5.62204999999992e-06 0 5.62799999999992e-06 0 5.62804999999992e-06 0 5.63399999999992e-06 0 5.63404999999992e-06 0 5.63999999999992e-06 0 5.64004999999992e-06 0 5.64599999999992e-06 0 5.64604999999992e-06 0 5.65199999999992e-06 0 5.65204999999992e-06 0 5.65799999999992e-06 0 5.65804999999992e-06 0 5.66399999999992e-06 0 5.66404999999992e-06 0 5.66999999999992e-06 0 5.67004999999992e-06 0 5.67599999999992e-06 0 5.67604999999992e-06 0 5.68199999999992e-06 0 5.68204999999992e-06 0 5.68799999999992e-06 0 5.68804999999992e-06 0 5.69399999999992e-06 0 5.69404999999992e-06 0 5.69999999999992e-06 0 5.70004999999992e-06 0 5.70599999999992e-06 0 5.70604999999992e-06 0 5.71199999999992e-06 0 5.71204999999992e-06 0 5.71799999999992e-06 0 5.71804999999992e-06 0 5.72399999999992e-06 0 5.72404999999992e-06 0 5.72999999999991e-06 0 5.73004999999991e-06 0 5.73599999999991e-06 0 5.73604999999991e-06 0 5.74199999999991e-06 0 5.74204999999991e-06 0 5.74799999999991e-06 0 5.74804999999991e-06 0 5.75399999999991e-06 0 5.75404999999991e-06 0 5.75999999999991e-06 0 5.76004999999991e-06 0 5.76599999999991e-06 0 5.76604999999991e-06 0 5.77199999999991e-06 0 5.77204999999991e-06 0 5.77799999999991e-06 0 5.77804999999991e-06 0 5.78399999999991e-06 0 5.78404999999991e-06 0 5.78999999999991e-06 0 5.79004999999991e-06 0 5.79599999999991e-06 0 5.79604999999991e-06 0 5.80199999999991e-06 0 5.80204999999991e-06 0 5.80799999999991e-06 0 5.80804999999991e-06 0 5.81399999999991e-06 0 5.81404999999991e-06 0 5.81999999999991e-06 0 5.82004999999991e-06 0 5.82599999999991e-06 0 5.82604999999991e-06 0 5.83199999999991e-06 0 5.83204999999991e-06 0 5.83799999999991e-06 0 5.83804999999991e-06 0 5.84399999999991e-06 0 5.84404999999991e-06 0 5.84999999999991e-06 0 5.85004999999991e-06 0 5.85599999999991e-06 0 5.85604999999991e-06 0 5.86199999999991e-06 0 5.86204999999991e-06 0 5.86799999999991e-06 0 5.86804999999991e-06 0 5.87399999999991e-06 0 5.87404999999991e-06 0 5.8799999999999e-06 0 5.8800499999999e-06 0 5.8859999999999e-06 0 5.8860499999999e-06 0 5.8919999999999e-06 0 5.8920499999999e-06 0 5.8979999999999e-06 0 5.8980499999999e-06 0 5.9039999999999e-06 0 5.9040499999999e-06 0 5.9099999999999e-06 0 5.9100499999999e-06 0 5.9159999999999e-06 0 5.9160499999999e-06 0 5.9219999999999e-06 0 5.9220499999999e-06 0 5.9279999999999e-06 0 5.9280499999999e-06 0 5.9339999999999e-06 0 5.9340499999999e-06 0 5.9399999999999e-06 0 5.9400499999999e-06 0 5.9459999999999e-06 0 5.9460499999999e-06 0 5.9519999999999e-06 0 5.9520499999999e-06 0 5.9579999999999e-06 0 5.9580499999999e-06 0 5.9639999999999e-06 0 5.9640499999999e-06 0 5.9699999999999e-06 0 5.9700499999999e-06 0 5.9759999999999e-06 0 5.9760499999999e-06 0 5.9819999999999e-06 0 5.9820499999999e-06 0 5.9879999999999e-06 0 5.9880499999999e-06 0 5.9939999999999e-06 0 5.9940499999999e-06 0 5.9999999999999e-06 0 6.0000499999999e-06 0 6.0059999999999e-06 0 6.0060499999999e-06 0 6.0119999999999e-06 0 6.0120499999999e-06 0 6.0179999999999e-06 0 6.0180499999999e-06 0 6.0239999999999e-06 0 6.0240499999999e-06 0 6.02999999999989e-06 0 6.03004999999989e-06 0 6.03599999999989e-06 0 6.03604999999989e-06 0 6.04199999999989e-06 0 6.04204999999989e-06 0 6.04799999999989e-06 0 6.04804999999989e-06 0 6.05399999999989e-06 0 6.05404999999989e-06 0 6.05999999999989e-06 0 6.06004999999989e-06 0 6.06599999999989e-06 0 6.06604999999989e-06 0 6.07199999999989e-06 0 6.07204999999989e-06 0 6.07799999999989e-06 0 6.07804999999989e-06 0 6.08399999999989e-06 0 6.08404999999989e-06 0 6.08999999999989e-06 0 6.09004999999989e-06 0 6.09599999999989e-06 0 6.09604999999989e-06 0 6.10199999999989e-06 0 6.10204999999989e-06 0 6.10799999999989e-06 0 6.10804999999989e-06 0 6.11399999999989e-06 0 6.11404999999989e-06 0 6.11999999999989e-06 0 6.12004999999989e-06 0 6.12599999999989e-06 0 6.12604999999989e-06 0 6.13199999999989e-06 0 6.13204999999989e-06 0 6.13799999999989e-06 0 6.13804999999989e-06 0 6.14399999999989e-06 0 6.14404999999989e-06 0 6.14999999999989e-06 0 6.15004999999989e-06 0 6.15599999999989e-06 0 6.15604999999989e-06 0 6.16199999999989e-06 0 6.16204999999989e-06 0 6.16799999999989e-06 0 6.16804999999989e-06 0 6.17399999999989e-06 0 6.17404999999989e-06 0 6.17999999999988e-06 0 6.18004999999989e-06 0 6.18599999999988e-06 0 6.18604999999988e-06 0 6.19199999999988e-06 0 6.19204999999988e-06 0 6.19799999999988e-06 0 6.19804999999988e-06 0 6.20399999999988e-06 0 6.20404999999988e-06 0 6.20999999999988e-06 0 6.21004999999988e-06 0 6.21599999999988e-06 0 6.21604999999988e-06 0 6.22199999999988e-06 0 6.22204999999988e-06 0 6.22799999999988e-06 0 6.22804999999988e-06 0 6.23399999999988e-06 0 6.23404999999988e-06 0 6.23999999999988e-06 0 6.24004999999988e-06 0 6.24599999999988e-06 0 6.24604999999988e-06 0 6.25199999999988e-06 0 6.25204999999988e-06 0 6.25799999999988e-06 0 6.25804999999988e-06 0 6.26399999999988e-06 0 6.26404999999988e-06 0 6.26999999999988e-06 0 6.27004999999988e-06 0 6.27599999999988e-06 0 6.27604999999988e-06 0 6.28199999999988e-06 0 6.28204999999988e-06 0 6.28799999999988e-06 0 6.28804999999988e-06 0 6.29399999999988e-06 0 6.29404999999988e-06 0 6.29999999999988e-06 0 6.30004999999988e-06 0 6.30599999999988e-06 0 6.30604999999988e-06 0 6.31199999999988e-06 0 6.31204999999988e-06 0 6.31799999999988e-06 0 6.31804999999988e-06 0 6.32399999999988e-06 0 6.32404999999988e-06 0 6.32999999999988e-06 0 6.33004999999988e-06 0 6.33599999999987e-06 0 6.33604999999987e-06 0 6.34199999999987e-06 0 6.34204999999987e-06 0 6.34799999999987e-06 0 6.34804999999987e-06 0 6.35399999999987e-06 0 6.35404999999987e-06 0 6.35999999999987e-06 0 6.36004999999987e-06 0 6.36599999999987e-06 0 6.36604999999987e-06 0 6.37199999999987e-06 0 6.37204999999987e-06 0 6.37799999999987e-06 0 6.37804999999987e-06 0 6.38399999999987e-06 0 6.38404999999987e-06 0 6.38999999999987e-06 0 6.39004999999987e-06 0 6.39599999999987e-06 0 6.39604999999987e-06 0 6.40199999999987e-06 0 6.40204999999987e-06 0 6.40799999999987e-06 0 6.40804999999987e-06 0 6.41399999999987e-06 0 6.41404999999987e-06 0 6.41999999999987e-06 0 6.42004999999987e-06 0 6.42599999999987e-06 0 6.42604999999987e-06 0 6.43199999999987e-06 0 6.43204999999987e-06 0 6.43799999999987e-06 0 6.43804999999987e-06 0 6.44399999999987e-06 0 6.44404999999987e-06 0 6.44999999999987e-06 0 6.45004999999987e-06 0 6.45599999999987e-06 0 6.45604999999987e-06 0 6.46199999999987e-06 0 6.46204999999987e-06 0 6.46799999999987e-06 0 6.46804999999987e-06 0 6.47399999999987e-06 0 6.47404999999987e-06 0 6.47999999999987e-06 0 6.48004999999987e-06 0 6.48599999999986e-06 0 6.48604999999986e-06 0 6.49199999999986e-06 0 6.49204999999986e-06 0 6.49799999999986e-06 0 6.49804999999986e-06 0 6.50399999999986e-06 0 6.50404999999986e-06 0 6.50999999999986e-06 0 6.51004999999986e-06 0 6.51599999999986e-06 0 6.51604999999986e-06 0 6.52199999999986e-06 0 6.52204999999986e-06 0 6.52799999999986e-06 0 6.52804999999986e-06 0 6.53399999999986e-06 0 6.53404999999986e-06 0 6.53999999999986e-06 0 6.54004999999986e-06 0 6.54599999999986e-06 0 6.54604999999986e-06 0 6.55199999999986e-06 0 6.55204999999986e-06 0 6.55799999999986e-06 0 6.55804999999986e-06 0 6.56399999999986e-06 0 6.56404999999986e-06 0 6.56999999999986e-06 0 6.57004999999986e-06 0 6.57599999999986e-06 0 6.57604999999986e-06 0 6.58199999999986e-06 0 6.58204999999986e-06 0 6.58799999999986e-06 0 6.58804999999986e-06 0 6.59399999999986e-06 0 6.59404999999986e-06 0 6.59999999999986e-06 0 6.60004999999986e-06 0 6.60599999999986e-06 0 6.60604999999986e-06 0 6.61199999999986e-06 0 6.61204999999986e-06 0 6.61799999999986e-06 0 6.61804999999986e-06 0 6.62399999999986e-06 0 6.62404999999986e-06 0 6.62999999999986e-06 0 6.63004999999986e-06 0 6.63599999999985e-06 0 6.63604999999985e-06 0 6.64199999999985e-06 0 6.64204999999985e-06 0 6.64799999999985e-06 0 6.64804999999985e-06 0 6.65399999999985e-06 0 6.65404999999985e-06 0 6.65999999999985e-06 0 6.66004999999985e-06 0 6.66599999999985e-06 0 6.66604999999985e-06 0 6.67199999999985e-06 0 6.67204999999985e-06 0 6.67799999999985e-06 0 6.67804999999985e-06 0 6.68399999999985e-06 0 6.68404999999985e-06 0 6.68999999999985e-06 0 6.69004999999985e-06 0 6.69599999999985e-06 0 6.69604999999985e-06 0 6.70199999999985e-06 0 6.70204999999985e-06 0 6.70799999999985e-06 0 6.70804999999985e-06 0 6.71399999999985e-06 0 6.71404999999985e-06 0 6.71999999999985e-06 0 6.72004999999985e-06 0 6.72599999999985e-06 0 6.72604999999985e-06 0 6.73199999999985e-06 0 6.73204999999985e-06 0 6.73799999999985e-06 0 6.73804999999985e-06 0 6.74399999999985e-06 0 6.74404999999985e-06 0 6.74999999999985e-06 0 6.75004999999985e-06 0 6.75599999999985e-06 0 6.75604999999985e-06 0 6.76199999999985e-06 0 6.76204999999985e-06 0 6.76799999999985e-06 0 6.76804999999985e-06 0 6.77399999999985e-06 0 6.77404999999985e-06 0 6.77999999999985e-06 0 6.78004999999985e-06 0 6.78599999999984e-06 0 6.78604999999985e-06 0 6.79199999999984e-06 0 6.79204999999984e-06 0 6.79799999999984e-06 0 6.79804999999984e-06 0 6.80399999999984e-06 0 6.80404999999984e-06 0 6.80999999999984e-06 0 6.81004999999984e-06 0 6.81599999999984e-06 0 6.81604999999984e-06 0 6.82199999999984e-06 0 6.82204999999984e-06 0 6.82799999999984e-06 0 6.82804999999984e-06 0 6.83399999999984e-06 0 6.83404999999984e-06 0 6.83999999999984e-06 0 6.84004999999984e-06 0 6.84599999999984e-06 0 6.84604999999984e-06 0 6.85199999999984e-06 0 6.85204999999984e-06 0 6.85799999999984e-06 0 6.85804999999984e-06 0 6.86399999999984e-06 0 6.86404999999984e-06 0 6.86999999999984e-06 0 6.87004999999984e-06 0 6.87599999999984e-06 0 6.87604999999984e-06 0 6.88199999999984e-06 0 6.88204999999984e-06 0 6.88799999999984e-06 0 6.88804999999984e-06 0 6.89399999999984e-06 0 6.89404999999984e-06 0 6.89999999999984e-06 0 6.90004999999984e-06 0 6.90599999999984e-06 0 6.90604999999984e-06 0 6.91199999999984e-06 0 6.91204999999984e-06 0 6.91799999999984e-06 0 6.91804999999984e-06 0 6.92399999999984e-06 0 6.92404999999984e-06 0 6.92999999999984e-06 0 6.93004999999984e-06 0 6.93599999999983e-06 0 6.93604999999984e-06 0 6.94199999999983e-06 0 6.94204999999983e-06 0 6.94799999999983e-06 0 6.94804999999983e-06 0 6.95399999999983e-06 0 6.95404999999983e-06 0 6.95999999999983e-06 0 6.96004999999983e-06 0 6.96599999999983e-06 0 6.96604999999983e-06 0 6.97199999999983e-06 0 6.97204999999983e-06 0 6.97799999999983e-06 0 6.97804999999983e-06 0 6.98399999999983e-06 0 6.98404999999983e-06 0 6.98999999999983e-06 0 6.99004999999983e-06 0 6.99599999999983e-06 0 6.99604999999983e-06 0 7.00199999999983e-06 0 7.00204999999983e-06 0 7.00799999999983e-06 0 7.00804999999983e-06 0 7.01399999999983e-06 0 7.01404999999983e-06 0 7.01999999999983e-06 0 7.02004999999983e-06 0 7.02599999999983e-06 0 7.02604999999983e-06 0 7.03199999999983e-06 0 7.03204999999983e-06 0 7.03799999999983e-06 0 7.03804999999983e-06 0 7.04399999999983e-06 0 7.04404999999983e-06 0 7.04999999999983e-06 0 7.05004999999983e-06 0 7.05599999999983e-06 0 7.05604999999983e-06 0 7.06199999999983e-06 0 7.06204999999983e-06 0 7.06799999999983e-06 0 7.06804999999983e-06 0 7.07399999999983e-06 0 7.07404999999983e-06 0 7.07999999999983e-06 0 7.08004999999983e-06 0 7.08599999999983e-06 0 7.08604999999983e-06 0 7.09199999999982e-06 0 7.09204999999982e-06 0 7.09799999999982e-06 0 7.09804999999982e-06 0 7.10399999999982e-06 0 7.10404999999982e-06 0 7.10999999999982e-06 0 7.11004999999982e-06 0 7.11599999999982e-06 0 7.11604999999982e-06 0 7.12199999999982e-06 0 7.12204999999982e-06 0 7.12799999999982e-06 0 7.12804999999982e-06 0 7.13399999999982e-06 0 7.13404999999982e-06 0 7.13999999999982e-06 0 7.14004999999982e-06 0 7.14599999999982e-06 0 7.14604999999982e-06 0 7.15199999999982e-06 0 7.15204999999982e-06 0 7.15799999999982e-06 0 7.15804999999982e-06 0 7.16399999999982e-06 0 7.16404999999982e-06 0 7.16999999999982e-06 0 7.17004999999982e-06 0 7.17599999999982e-06 0 7.17604999999982e-06 0 7.18199999999982e-06 0 7.18204999999982e-06 0 7.18799999999982e-06 0 7.18804999999982e-06 0 7.19399999999982e-06 0 7.19404999999982e-06 0 7.19999999999982e-06 0 7.20004999999982e-06 0 7.20599999999982e-06 0 7.20604999999982e-06 0 7.21199999999982e-06 0 7.21204999999982e-06 0 7.21799999999982e-06 0 7.21804999999982e-06 0 7.22399999999982e-06 0 7.22404999999982e-06 0 7.22999999999982e-06 0 7.23004999999982e-06 0 7.23599999999982e-06 0 7.23604999999982e-06 0 7.24199999999981e-06 0 7.24204999999981e-06 0 7.24799999999981e-06 0 7.24804999999981e-06 0 7.25399999999981e-06 0 7.25404999999981e-06 0 7.25999999999981e-06 0 7.26004999999981e-06 0 7.26599999999981e-06 0 7.26604999999981e-06 0 7.27199999999981e-06 0 7.27204999999981e-06 0 7.27799999999981e-06 0 7.27804999999981e-06 0 7.28399999999981e-06 0 7.28404999999981e-06 0 7.28999999999981e-06 0 7.29004999999981e-06 0 7.29599999999981e-06 0 7.29604999999981e-06 0 7.30199999999981e-06 0 7.30204999999981e-06 0 7.30799999999981e-06 0 7.30804999999981e-06 0 7.31399999999981e-06 0 7.31404999999981e-06 0 7.31999999999981e-06 0 7.32004999999981e-06 0 7.32599999999981e-06 0 7.32604999999981e-06 0 7.33199999999981e-06 0 7.33204999999981e-06 0 7.33799999999981e-06 0 7.33804999999981e-06 0 7.34399999999981e-06 0 7.34404999999981e-06 0 7.34999999999981e-06 0 7.35004999999981e-06 0 7.35599999999981e-06 0 7.35604999999981e-06 0 7.36199999999981e-06 0 7.36204999999981e-06 0 7.36799999999981e-06 0 7.36804999999981e-06 0 7.37399999999981e-06 0 7.37404999999981e-06 0 7.37999999999981e-06 0 7.38004999999981e-06 0 7.38599999999981e-06 0 7.38604999999981e-06 0 7.3919999999998e-06 0 7.3920499999998e-06 0 7.3979999999998e-06 0 7.3980499999998e-06 0 7.4039999999998e-06 0 7.4040499999998e-06 0 7.4099999999998e-06 0 7.4100499999998e-06 0 7.4159999999998e-06 0 7.4160499999998e-06 0 7.4219999999998e-06 0 7.4220499999998e-06 0 7.4279999999998e-06 0 7.4280499999998e-06 0 7.4339999999998e-06 0 7.4340499999998e-06 0 7.4399999999998e-06 0 7.4400499999998e-06 0 7.4459999999998e-06 0 7.4460499999998e-06 0 7.4519999999998e-06 0 7.4520499999998e-06 0 7.4579999999998e-06 0 7.4580499999998e-06 0 7.4639999999998e-06 0 7.4640499999998e-06 0 7.4699999999998e-06 0 7.4700499999998e-06 0 7.4759999999998e-06 0 7.4760499999998e-06 0 7.4819999999998e-06 0 7.4820499999998e-06 0 7.4879999999998e-06 0 7.4880499999998e-06 0 7.4939999999998e-06 0 7.4940499999998e-06 0 7.4999999999998e-06 0 7.5000499999998e-06 0 7.5059999999998e-06 0 7.5060499999998e-06 0 7.5119999999998e-06 0 7.5120499999998e-06 0 7.5179999999998e-06 0 7.5180499999998e-06 0 7.5239999999998e-06 0 7.5240499999998e-06 0 7.5299999999998e-06 0 7.5300499999998e-06 0 7.5359999999998e-06 0 7.5360499999998e-06 0 7.54199999999979e-06 0 7.5420499999998e-06 0 7.54799999999979e-06 0 7.54804999999979e-06 0 7.55399999999979e-06 0 7.55404999999979e-06 0 7.55999999999979e-06 0 7.56004999999979e-06 0 7.56599999999979e-06 0 7.56604999999979e-06 0 7.57199999999979e-06 0 7.57204999999979e-06 0 7.57799999999979e-06 0 7.57804999999979e-06 0 7.58399999999979e-06 0 7.58404999999979e-06 0 7.58999999999979e-06 0 7.59004999999979e-06 0 7.59599999999979e-06 0 7.59604999999979e-06 0 7.60199999999979e-06 0 7.60204999999979e-06 0 7.60799999999979e-06 0 7.60804999999979e-06 0 7.61399999999979e-06 0 7.61404999999979e-06 0 7.61999999999979e-06 0 7.62004999999979e-06 0 7.62599999999979e-06 0 7.62604999999979e-06 0 7.63199999999979e-06 0 7.63204999999979e-06 0 7.63799999999979e-06 0 7.63804999999979e-06 0 7.64399999999979e-06 0 7.64404999999979e-06 0 7.64999999999979e-06 0 7.65004999999979e-06 0 7.65599999999979e-06 0 7.65604999999979e-06 0 7.66199999999979e-06 0 7.66204999999979e-06 0 7.66799999999979e-06 0 7.66804999999979e-06 0 7.67399999999979e-06 0 7.67404999999979e-06 0 7.67999999999979e-06 0 7.68004999999979e-06 0 7.68599999999979e-06 0 7.68604999999979e-06 0 7.69199999999979e-06 0 7.69204999999979e-06 0 7.69799999999978e-06 0 7.69804999999978e-06 0 7.70399999999978e-06 0 7.70404999999978e-06 0 7.70999999999978e-06 0 7.71004999999978e-06 0 7.71599999999978e-06 0 7.71604999999978e-06 0 7.72199999999978e-06 0 7.72204999999978e-06 0 7.72799999999978e-06 0 7.72804999999978e-06 0 7.73399999999978e-06 0 7.73404999999978e-06 0 7.73999999999978e-06 0 7.74004999999978e-06 0 7.74599999999978e-06 0 7.74604999999978e-06 0 7.75199999999978e-06 0 7.75204999999978e-06 0 7.75799999999978e-06 0 7.75804999999978e-06 0 7.76399999999978e-06 0 7.76404999999978e-06 0 7.76999999999978e-06 0 7.77004999999978e-06 0 7.77599999999978e-06 0 7.77604999999978e-06 0 7.78199999999978e-06 0 7.78204999999978e-06 0 7.78799999999978e-06 0 7.78804999999978e-06 0 7.79399999999978e-06 0 7.79404999999978e-06 0 7.79999999999978e-06 0 7.80004999999978e-06 0 7.80599999999978e-06 0 7.80604999999978e-06 0 7.81199999999978e-06 0 7.81204999999978e-06 0 7.81799999999978e-06 0 7.81804999999978e-06 0 7.82399999999978e-06 0 7.82404999999978e-06 0 7.82999999999978e-06 0 7.83004999999978e-06 0 7.83599999999978e-06 0 7.83604999999978e-06 0 7.84199999999978e-06 0 7.84204999999978e-06 0 7.84799999999977e-06 0 7.84804999999977e-06 0 7.85399999999977e-06 0 7.85404999999977e-06 0 7.85999999999977e-06 0 7.86004999999977e-06 0 7.86599999999977e-06 0 7.86604999999977e-06 0 7.87199999999977e-06 0 7.87204999999977e-06 0 7.87799999999977e-06 0 7.87804999999977e-06 0 7.88399999999977e-06 0 7.88404999999977e-06 0 7.88999999999977e-06 0 7.89004999999977e-06 0 7.89599999999977e-06 0 7.89604999999977e-06 0 7.90199999999977e-06 0 7.90204999999977e-06 0 7.90799999999977e-06 0 7.90804999999977e-06 0 7.91399999999977e-06 0 7.91404999999977e-06 0 7.91999999999977e-06 0 7.92004999999977e-06 0 7.92599999999977e-06 0 7.92604999999977e-06 0 7.93199999999977e-06 0 7.93204999999977e-06 0 7.93799999999977e-06 0 7.93804999999977e-06 0 7.94399999999977e-06 0 7.94404999999977e-06 0 7.94999999999977e-06 0 7.95004999999977e-06 0 7.95599999999977e-06 0 7.95604999999977e-06 0 7.96199999999977e-06 0 7.96204999999977e-06 0 7.96799999999977e-06 0 7.96804999999977e-06 0 7.97399999999977e-06 0 7.97404999999977e-06 0 7.97999999999977e-06 0 7.98004999999977e-06 0 7.98599999999977e-06 0 7.98604999999977e-06 0 7.99199999999977e-06 0 7.99204999999977e-06 0 7.99799999999976e-06 0 7.99804999999976e-06 0 8.00399999999976e-06 0 8.00404999999976e-06 0 8.00999999999976e-06 0 8.01004999999976e-06 0 8.01599999999976e-06 0 8.01604999999976e-06 0 8.02199999999976e-06 0 8.02204999999976e-06 0 8.02799999999976e-06 0 8.02804999999976e-06 0 8.03399999999976e-06 0 8.03404999999976e-06 0 8.03999999999976e-06 0 8.04004999999976e-06 0 8.04599999999976e-06 0 8.04604999999976e-06 0 8.05199999999976e-06 0 8.05204999999976e-06 0 8.05799999999976e-06 0 8.05804999999976e-06 0 8.06399999999976e-06 0 8.06404999999976e-06 0 8.06999999999976e-06 0 8.07004999999976e-06 0 8.07599999999976e-06 0 8.07604999999976e-06 0 8.08199999999976e-06 0 8.08204999999976e-06 0 8.08799999999976e-06 0 8.08804999999976e-06 0 8.09399999999976e-06 0 8.09404999999976e-06 0 8.09999999999976e-06 0 8.10004999999976e-06 0 8.10599999999976e-06 0 8.10604999999976e-06 0 8.11199999999976e-06 0 8.11204999999976e-06 0 8.11799999999976e-06 0 8.11804999999976e-06 0 8.12399999999976e-06 0 8.12404999999976e-06 0 8.12999999999976e-06 0 8.13004999999976e-06 0 8.13599999999976e-06 0 8.13604999999976e-06 0 8.14199999999976e-06 0 8.14204999999976e-06 0 8.14799999999975e-06 0 8.14804999999976e-06 0 8.15399999999975e-06 0 8.15404999999975e-06 0 8.15999999999975e-06 0 8.16004999999975e-06 0 8.16599999999975e-06 0 8.16604999999975e-06 0 8.17199999999975e-06 0 8.17204999999975e-06 0 8.17799999999975e-06 0 8.17804999999975e-06 0 8.18399999999975e-06 0 8.18404999999975e-06 0 8.18999999999975e-06 0 8.19004999999975e-06 0 8.19599999999975e-06 0 8.19604999999975e-06 0 8.20199999999975e-06 0 8.20204999999975e-06 0 8.20799999999975e-06 0 8.20804999999975e-06 0 8.21399999999975e-06 0 8.21404999999975e-06 0 8.21999999999975e-06 0 8.22004999999975e-06 0 8.22599999999975e-06 0 8.22604999999975e-06 0 8.23199999999975e-06 0 8.23204999999975e-06 0 8.23799999999975e-06 0 8.23804999999975e-06 0 8.24399999999975e-06 0 8.24404999999975e-06 0 8.24999999999975e-06 0 8.25004999999975e-06 0 8.25599999999975e-06 0 8.25604999999975e-06 0 8.26199999999975e-06 0 8.26204999999975e-06 0 8.26799999999975e-06 0 8.26804999999975e-06 0 8.27399999999975e-06 0 8.27404999999975e-06 0 8.27999999999975e-06 0 8.28004999999975e-06 0 8.28599999999975e-06 0 8.28604999999975e-06 0 8.29199999999975e-06 0 8.29204999999975e-06 0 8.29799999999975e-06 0 8.29804999999975e-06 0 8.30399999999974e-06 0 8.30404999999974e-06 0 8.30999999999974e-06 0 8.31004999999974e-06 0 8.31599999999974e-06 0 8.31604999999974e-06 0 8.32199999999974e-06 0 8.32204999999974e-06 0 8.32799999999974e-06 0 8.32804999999974e-06 0 8.33399999999974e-06 0 8.33404999999974e-06 0 8.33999999999974e-06 0 8.34004999999974e-06 0 8.34599999999974e-06 0 8.34604999999974e-06 0 8.35199999999974e-06 0 8.35204999999974e-06 0 8.35799999999974e-06 0 8.35804999999974e-06 0 8.36399999999974e-06 0 8.36404999999974e-06 0 8.36999999999974e-06 0 8.37004999999974e-06 0 8.37599999999974e-06 0 8.37604999999974e-06 0 8.38199999999974e-06 0 8.38204999999974e-06 0 8.38799999999974e-06 0 8.38804999999974e-06 0 8.39399999999974e-06 0 8.39404999999974e-06 0 8.39999999999974e-06 0 8.40004999999974e-06 0 8.40599999999974e-06 0 8.40604999999974e-06 0 8.41199999999974e-06 0 8.41204999999974e-06 0 8.41799999999974e-06 0 8.41804999999974e-06 0 8.42399999999974e-06 0 8.42404999999974e-06 0 8.42999999999974e-06 0 8.43004999999974e-06 0 8.43599999999974e-06 0 8.43604999999974e-06 0 8.44199999999974e-06 0 8.44204999999974e-06 0 8.44799999999974e-06 0 8.44804999999974e-06 0 8.45399999999973e-06 0 8.45404999999973e-06 0 8.45999999999973e-06 0 8.46004999999973e-06 0 8.46599999999973e-06 0 8.46604999999973e-06 0 8.47199999999973e-06 0 8.47204999999973e-06 0 8.47799999999973e-06 0 8.47804999999973e-06 0 8.48399999999973e-06 0 8.48404999999973e-06 0 8.48999999999973e-06 0 8.49004999999973e-06 0 8.49599999999973e-06 0 8.49604999999973e-06 0 8.50199999999973e-06 0 8.50204999999973e-06 0 8.50799999999973e-06 0 8.50804999999973e-06 0 8.51399999999973e-06 0 8.51404999999973e-06 0 8.51999999999973e-06 0 8.52004999999973e-06 0 8.52599999999973e-06 0 8.52604999999973e-06 0 8.53199999999973e-06 0 8.53204999999973e-06 0 8.53799999999973e-06 0 8.53804999999973e-06 0 8.54399999999973e-06 0 8.54404999999973e-06 0 8.54999999999973e-06 0 8.55004999999973e-06 0 8.55599999999973e-06 0 8.55604999999973e-06 0 8.56199999999973e-06 0 8.56204999999973e-06 0 8.56799999999973e-06 0 8.56804999999973e-06 0 8.57399999999973e-06 0 8.57404999999973e-06 0 8.57999999999973e-06 0 8.58004999999973e-06 0 8.58599999999973e-06 0 8.58604999999973e-06 0 8.59199999999973e-06 0 8.59204999999973e-06 0 8.59799999999973e-06 0 8.59804999999973e-06 0 8.60399999999972e-06 0 8.60404999999972e-06 0 8.60999999999972e-06 0 8.61004999999972e-06 0 8.61599999999972e-06 0 8.61604999999972e-06 0 8.62199999999972e-06 0 8.62204999999972e-06 0 8.62799999999972e-06 0 8.62804999999972e-06 0 8.63399999999972e-06 0 8.63404999999972e-06 0 8.63999999999972e-06 0 8.64004999999972e-06 0 8.64599999999972e-06 0 8.64604999999972e-06 0 8.65199999999972e-06 0 8.65204999999972e-06 0 8.65799999999972e-06 0 8.65804999999972e-06 0 8.66399999999972e-06 0 8.66404999999972e-06 0 8.66999999999972e-06 0 8.67004999999972e-06 0 8.67599999999972e-06 0 8.67604999999972e-06 0 8.68199999999972e-06 0 8.68204999999972e-06 0 8.68799999999972e-06 0 8.68804999999972e-06 0 8.69399999999972e-06 0 8.69404999999972e-06 0 8.69999999999972e-06 0 8.70004999999972e-06 0 8.70599999999972e-06 0 8.70604999999972e-06 0 8.71199999999972e-06 0 8.71204999999972e-06 0 8.71799999999972e-06 0 8.71804999999972e-06 0 8.72399999999972e-06 0 8.72404999999972e-06 0 8.72999999999972e-06 0 8.73004999999972e-06 0 8.73599999999972e-06 0 8.73604999999972e-06 0 8.74199999999972e-06 0 8.74204999999972e-06 0 8.74799999999972e-06 0 8.74804999999972e-06 0 8.75399999999971e-06 0 8.75404999999972e-06 0 8.75999999999971e-06 0 8.76004999999971e-06 0 8.76599999999971e-06 0 8.76604999999971e-06 0 8.77199999999971e-06 0 8.77204999999971e-06 0 8.77799999999971e-06 0 8.77804999999971e-06 0 8.78399999999971e-06 0 8.78404999999971e-06 0 8.78999999999971e-06 0 8.79004999999971e-06 0 8.79599999999971e-06 0 8.79604999999971e-06 0 8.80199999999971e-06 0 8.80204999999971e-06 0 8.80799999999971e-06 0 8.80804999999971e-06 0 8.81399999999971e-06 0 8.81404999999971e-06 0 8.81999999999971e-06 0 8.82004999999971e-06 0 8.82599999999971e-06 0 8.82604999999971e-06 0 8.83199999999971e-06 0 8.83204999999971e-06 0 8.83799999999971e-06 0 8.83804999999971e-06 0 8.84399999999971e-06 0 8.84404999999971e-06 0 8.84999999999971e-06 0 8.85004999999971e-06 0 8.85599999999971e-06 0 8.85604999999971e-06 0 8.86199999999971e-06 0 8.86204999999971e-06 0 8.86799999999971e-06 0 8.86804999999971e-06 0 8.87399999999971e-06 0 8.87404999999971e-06 0 8.87999999999971e-06 0 8.88004999999971e-06 0 8.88599999999971e-06 0 8.88604999999971e-06 0 8.89199999999971e-06 0 8.89204999999971e-06 0 8.89799999999971e-06 0 8.89804999999971e-06 0 8.90399999999971e-06 0 8.90404999999971e-06 0 8.9099999999997e-06 0 8.9100499999997e-06 0 8.9159999999997e-06 0 8.9160499999997e-06 0 8.9219999999997e-06 0 8.9220499999997e-06 0 8.9279999999997e-06 0 8.9280499999997e-06 0 8.9339999999997e-06 0 8.9340499999997e-06 0 8.9399999999997e-06 0 8.9400499999997e-06 0 8.9459999999997e-06 0 8.9460499999997e-06 0 8.9519999999997e-06 0 8.9520499999997e-06 0 8.9579999999997e-06 0 8.9580499999997e-06 0 8.9639999999997e-06 0 8.9640499999997e-06 0 8.9699999999997e-06 0 8.9700499999997e-06 0 8.9759999999997e-06 0 8.9760499999997e-06 0 8.9819999999997e-06 0 8.9820499999997e-06 0 8.9879999999997e-06 0 8.9880499999997e-06 0 8.9939999999997e-06 0 8.9940499999997e-06 0 8.9999999999997e-06 0 9.0000499999997e-06 0 9.0059999999997e-06 0 9.0060499999997e-06 0 9.0119999999997e-06 0 9.0120499999997e-06 0 9.0179999999997e-06 0 9.0180499999997e-06 0 9.0239999999997e-06 0 9.0240499999997e-06 0 9.0299999999997e-06 0 9.0300499999997e-06 0 9.0359999999997e-06 0 9.0360499999997e-06 0 9.0419999999997e-06 0 9.0420499999997e-06 0 9.0479999999997e-06 0 9.0480499999997e-06 0 9.0539999999997e-06 0 9.0540499999997e-06 0 9.05999999999969e-06 0 9.06004999999969e-06 0 9.06599999999969e-06 0 9.06604999999969e-06 0 9.07199999999969e-06 0 9.07204999999969e-06 0 9.07799999999969e-06 0 9.07804999999969e-06 0 9.08399999999969e-06 0 9.08404999999969e-06 0 9.08999999999969e-06 0 9.09004999999969e-06 0 9.09599999999969e-06 0 9.09604999999969e-06 0 9.10199999999969e-06 0 9.10204999999969e-06 0 9.10799999999969e-06 0 9.10804999999969e-06 0 9.11399999999969e-06 0 9.11404999999969e-06 0 9.11999999999969e-06 0 9.12004999999969e-06 0 9.12599999999969e-06 0 9.12604999999969e-06 0 9.13199999999969e-06 0 9.13204999999969e-06 0 9.13799999999969e-06 0 9.13804999999969e-06 0 9.14399999999969e-06 0 9.14404999999969e-06 0 9.14999999999969e-06 0 9.15004999999969e-06 0 9.15599999999969e-06 0 9.15604999999969e-06 0 9.16199999999969e-06 0 9.16204999999969e-06 0 9.16799999999969e-06 0 9.16804999999969e-06 0 9.17399999999969e-06 0 9.17404999999969e-06 0 9.17999999999969e-06 0 9.18004999999969e-06 0 9.18599999999969e-06 0 9.18604999999969e-06 0 9.19199999999969e-06 0 9.19204999999969e-06 0 9.19799999999969e-06 0 9.19804999999969e-06 0 9.20399999999969e-06 0 9.20404999999969e-06 0 9.20999999999968e-06 0 9.21004999999968e-06 0 9.21599999999968e-06 0 9.21604999999968e-06 0 9.22199999999968e-06 0 9.22204999999968e-06 0 9.22799999999968e-06 0 9.22804999999968e-06 0 9.23399999999968e-06 0 9.23404999999968e-06 0 9.23999999999968e-06 0 9.24004999999968e-06 0 9.24599999999968e-06 0 9.24604999999968e-06 0 9.25199999999968e-06 0 9.25204999999968e-06 0 9.25799999999968e-06 0 9.25804999999968e-06 0 9.26399999999968e-06 0 9.26404999999968e-06 0 9.26999999999968e-06 0 9.27004999999968e-06 0 9.27599999999968e-06 0 9.27604999999968e-06 0 9.28199999999968e-06 0 9.28204999999968e-06 0 9.28799999999968e-06 0 9.28804999999968e-06 0 9.29399999999968e-06 0 9.29404999999968e-06 0 9.29999999999968e-06 0 9.30004999999968e-06 0 9.30599999999968e-06 0 9.30604999999968e-06 0 9.31199999999968e-06 0 9.31204999999968e-06 0 9.31799999999968e-06 0 9.31804999999968e-06 0 9.32399999999968e-06 0 9.32404999999968e-06 0 9.32999999999968e-06 0 9.33004999999968e-06 0 9.33599999999968e-06 0 9.33604999999968e-06 0 9.34199999999968e-06 0 9.34204999999968e-06 0 9.34799999999968e-06 0 9.34804999999968e-06 0 9.35399999999968e-06 0 9.35404999999968e-06 0 9.35999999999967e-06 0 9.36004999999968e-06 0 9.36599999999967e-06 0 9.36604999999967e-06 0 9.37199999999967e-06 0 9.37204999999967e-06 0 9.37799999999967e-06 0 9.37804999999967e-06 0 9.38399999999967e-06 0 9.38404999999967e-06 0 9.38999999999967e-06 0 9.39004999999967e-06 0 9.39599999999967e-06 0 9.39604999999967e-06 0 9.40199999999967e-06 0 9.40204999999967e-06 0 9.40799999999967e-06 0 9.40804999999967e-06 0 9.41399999999967e-06 0 9.41404999999967e-06 0 9.41999999999967e-06 0 9.42004999999967e-06 0 9.42599999999967e-06 0 9.42604999999967e-06 0 9.43199999999967e-06 0 9.43204999999967e-06 0 9.43799999999967e-06 0 9.43804999999967e-06 0 9.44399999999967e-06 0 9.44404999999967e-06 0 9.44999999999967e-06 0 9.45004999999967e-06 0 9.45599999999967e-06 0 9.45604999999967e-06 0 9.46199999999967e-06 0 9.46204999999967e-06 0 9.46799999999967e-06 0 9.46804999999967e-06 0 9.47399999999967e-06 0 9.47404999999967e-06 0 9.47999999999967e-06 0 9.48004999999967e-06 0 9.48599999999967e-06 0 9.48604999999967e-06 0 9.49199999999967e-06 0 9.49204999999967e-06 0 9.49799999999967e-06 0 9.49804999999967e-06 0 9.50399999999967e-06 0 9.50404999999967e-06 0 9.50999999999967e-06 0 9.51004999999967e-06 0 9.51599999999966e-06 0 9.51604999999966e-06 0 9.52199999999966e-06 0 9.52204999999966e-06 0 9.52799999999966e-06 0 9.52804999999966e-06 0 9.53399999999966e-06 0 9.53404999999966e-06 0 9.53999999999966e-06 0 9.54004999999966e-06 0 9.54599999999966e-06 0 9.54604999999966e-06 0 9.55199999999966e-06 0 9.55204999999966e-06 0 9.55799999999966e-06 0 9.55804999999966e-06 0 9.56399999999966e-06 0 9.56404999999966e-06 0 9.56999999999966e-06 0 9.57004999999966e-06 0 9.57599999999966e-06 0 9.57604999999966e-06 0 9.58199999999966e-06 0 9.58204999999966e-06 0 9.58799999999966e-06 0 9.58804999999966e-06 0 9.59399999999966e-06 0 9.59404999999966e-06 0 9.59999999999966e-06 0 9.60004999999966e-06 0 9.60599999999966e-06 0 9.60604999999966e-06 0 9.61199999999966e-06 0 9.61204999999966e-06 0 9.61799999999966e-06 0 9.61804999999966e-06 0 9.62399999999966e-06 0 9.62404999999966e-06 0 9.62999999999966e-06 0 9.63004999999966e-06 0 9.63599999999966e-06 0 9.63604999999966e-06 0 9.64199999999966e-06 0 9.64204999999966e-06 0 9.64799999999966e-06 0 9.64804999999966e-06 0 9.65399999999966e-06 0 9.65404999999966e-06 0 9.65999999999966e-06 0 9.66004999999966e-06 0 9.66599999999965e-06 0 9.66604999999965e-06 0 9.67199999999965e-06 0 9.67204999999965e-06 0 9.67799999999965e-06 0 9.67804999999965e-06 0 9.68399999999965e-06 0 9.68404999999965e-06 0 9.68999999999965e-06 0 9.69004999999965e-06 0 9.69599999999965e-06 0 9.69604999999965e-06 0 9.70199999999965e-06 0 9.70204999999965e-06 0 9.70799999999965e-06 0 9.70804999999965e-06 0 9.71399999999965e-06 0 9.71404999999965e-06 0 9.71999999999965e-06 0 9.72004999999965e-06 0 9.72599999999965e-06 0 9.72604999999965e-06 0 9.73199999999965e-06 0 9.73204999999965e-06 0 9.73799999999965e-06 0 9.73804999999965e-06 0 9.74399999999965e-06 0 9.74404999999965e-06 0 9.74999999999965e-06 0 9.75004999999965e-06 0 9.75599999999965e-06 0 9.75604999999965e-06 0 9.76199999999965e-06 0 9.76204999999965e-06 0 9.76799999999965e-06 0 9.76804999999965e-06 0 9.77399999999965e-06 0 9.77404999999965e-06 0 9.77999999999965e-06 0 9.78004999999965e-06 0 9.78599999999965e-06 0 9.78604999999965e-06 0 9.79199999999965e-06 0 9.79204999999965e-06 0 9.79799999999965e-06 0 9.79804999999965e-06 0 9.80399999999965e-06 0 9.80404999999965e-06 0 9.80999999999965e-06 0 9.81004999999965e-06 0 9.81599999999964e-06 0 9.81604999999964e-06 0 9.82199999999964e-06 0 9.82204999999964e-06 0 9.82799999999964e-06 0 9.82804999999964e-06 0 9.83399999999964e-06 0 9.83404999999964e-06 0 9.83999999999964e-06 0 9.84004999999964e-06 0 9.84599999999964e-06 0 9.84604999999964e-06 0 9.85199999999964e-06 0 9.85204999999964e-06 0 9.85799999999964e-06 0 9.85804999999964e-06 0 9.86399999999964e-06 0 9.86404999999964e-06 0 9.86999999999964e-06 0 9.87004999999964e-06 0 9.87599999999964e-06 0 9.87604999999964e-06 0 9.88199999999964e-06 0 9.88204999999964e-06 0 9.88799999999964e-06 0 9.88804999999964e-06 0 9.89399999999964e-06 0 9.89404999999964e-06 0 9.89999999999964e-06 0 9.90004999999964e-06 0 9.90599999999964e-06 0 9.90604999999964e-06 0 9.91199999999964e-06 0 9.91204999999964e-06 0 9.91799999999964e-06 0 9.91804999999964e-06 0 9.92399999999964e-06 0 9.92404999999964e-06 0 9.92999999999964e-06 0 9.93004999999964e-06 0 9.93599999999964e-06 0 9.93604999999964e-06 0 9.94199999999964e-06 0 9.94204999999964e-06 0 9.94799999999964e-06 0 9.94804999999964e-06 0 9.95399999999964e-06 0 9.95404999999964e-06 0 9.95999999999964e-06 0 9.96004999999964e-06 0 9.96599999999963e-06 0 9.96604999999963e-06 0 9.97199999999963e-06 0 9.97204999999963e-06 0 9.97799999999963e-06 0 9.97804999999963e-06 0 9.98399999999963e-06 0 9.98404999999963e-06 0 9.98999999999963e-06 0 9.99004999999963e-06 0 9.99599999999963e-06 0 9.99604999999963e-06 0 1.00019999999996e-05 0 1.00020499999996e-05 0 1.00079999999996e-05 0 1.00080499999996e-05 0 1.00139999999996e-05 0 1.00140499999996e-05 0 1.00199999999996e-05 0 1.00200499999996e-05 0 1.00259999999996e-05 0 1.00260499999996e-05 0 1.00319999999996e-05 0 1.00320499999996e-05 0 1.00379999999996e-05 0 1.00380499999996e-05 0 1.00439999999996e-05 0 1.00440499999996e-05 0 1.00499999999996e-05 0 1.00500499999996e-05 0 1.00559999999996e-05 0 1.00560499999996e-05 0 1.00619999999996e-05 0 1.00620499999996e-05 0 1.00679999999996e-05 0 1.00680499999996e-05 0 1.00739999999996e-05 0 1.00740499999996e-05 0 1.00799999999996e-05 0 1.00800499999996e-05 0 1.00859999999996e-05 0 1.00860499999996e-05 0 1.00919999999996e-05 0 1.00920499999996e-05 0 1.00979999999996e-05 0 1.00980499999996e-05 0 1.01039999999996e-05 0 1.01040499999996e-05 0 1.01099999999996e-05 0 1.01100499999996e-05 0 1.01159999999996e-05 0 1.01160499999996e-05 0 1.01219999999996e-05 0 1.01220499999996e-05 0 1.01279999999996e-05 0 1.01280499999996e-05 0 1.01339999999996e-05 0 1.01340499999996e-05 0 1.01399999999996e-05 0 1.01400499999996e-05 0 1.01459999999996e-05 0 1.01460499999996e-05 0 1.01519999999996e-05 0 1.01520499999996e-05 0 1.01579999999996e-05 0 1.01580499999996e-05 0 1.01639999999996e-05 0 1.01640499999996e-05 0 1.01699999999996e-05 0 1.01700499999996e-05 0 1.01759999999996e-05 0 1.01760499999996e-05 0 1.01819999999996e-05 0 1.01820499999996e-05 0 1.01879999999996e-05 0 1.01880499999996e-05 0 1.01939999999996e-05 0 1.01940499999996e-05 0 1.01999999999996e-05 0 1.02000499999996e-05 0 1.02059999999996e-05 0 1.02060499999996e-05 0 1.02119999999996e-05 0 1.02120499999996e-05 0 1.02179999999996e-05 0 1.02180499999996e-05 0 1.02239999999996e-05 0 1.02240499999996e-05 0 1.02299999999996e-05 0 1.02300499999996e-05 0 1.02359999999996e-05 0 1.02360499999996e-05 0 1.02419999999996e-05 0 1.02420499999996e-05 0 1.02479999999996e-05 0 1.02480499999996e-05 0 1.02539999999996e-05 0 1.02540499999996e-05 0 1.02599999999996e-05 0 1.02600499999996e-05 0 1.02659999999996e-05 0 1.02660499999996e-05 0 1.02719999999996e-05 0 1.02720499999996e-05 0 1.02779999999996e-05 0 1.02780499999996e-05 0 1.02839999999996e-05 0 1.02840499999996e-05 0 1.02899999999996e-05 0 1.02900499999996e-05 0 1.02959999999996e-05 0 1.02960499999996e-05 0 1.03019999999996e-05 0 1.03020499999996e-05 0 1.03079999999996e-05 0 1.03080499999996e-05 0 1.03139999999996e-05 0 1.03140499999996e-05 0 1.03199999999996e-05 0 1.03200499999996e-05 0 1.03259999999996e-05 0 1.03260499999996e-05 0 1.03319999999996e-05 0 1.03320499999996e-05 0 1.03379999999996e-05 0 1.03380499999996e-05 0 1.03439999999996e-05 0 1.03440499999996e-05 0 1.03499999999996e-05 0 1.03500499999996e-05 0 1.03559999999996e-05 0 1.03560499999996e-05 0 1.03619999999996e-05 0 1.03620499999996e-05 0 1.03679999999996e-05 0 1.03680499999996e-05 0 1.03739999999996e-05 0 1.03740499999996e-05 0 1.03799999999996e-05 0 1.03800499999996e-05 0 1.03859999999996e-05 0 1.03860499999996e-05 0 1.03919999999996e-05 0 1.03920499999996e-05 0 1.03979999999996e-05 0 1.03980499999996e-05 0 1.04039999999996e-05 0 1.04040499999996e-05 0 1.04099999999996e-05 0 1.04100499999996e-05 0 1.04159999999996e-05 0 1.04160499999996e-05 0 1.04219999999996e-05 0 1.04220499999996e-05 0 1.04279999999996e-05 0 1.04280499999996e-05 0 1.04339999999996e-05 0 1.04340499999996e-05 0 1.04399999999996e-05 0 1.04400499999996e-05 0 1.04459999999996e-05 0 1.04460499999996e-05 0 1.04519999999996e-05 0 1.04520499999996e-05 0 1.04579999999996e-05 0 1.04580499999996e-05 0 1.04639999999996e-05 0 1.04640499999996e-05 0 1.04699999999996e-05 0 1.04700499999996e-05 0 1.04759999999996e-05 0 1.04760499999996e-05 0 1.04819999999996e-05 0 1.04820499999996e-05 0 1.04879999999996e-05 0 1.04880499999996e-05 0 1.04939999999996e-05 0 1.04940499999996e-05 0 1.04999999999996e-05 0 1.05000499999996e-05 0 1.05059999999996e-05 0 1.05060499999996e-05 0 1.05119999999996e-05 0 1.05120499999996e-05 0 1.05179999999996e-05 0 1.05180499999996e-05 0 1.05239999999996e-05 0 1.05240499999996e-05 0 1.05299999999996e-05 0 1.05300499999996e-05 0 1.05359999999996e-05 0 1.05360499999996e-05 0 1.05419999999996e-05 0 1.05420499999996e-05 0 1.05479999999996e-05 0 1.05480499999996e-05 0 1.05539999999996e-05 0 1.05540499999996e-05 0 1.05599999999996e-05 0 1.05600499999996e-05 0 1.05659999999996e-05 0 1.05660499999996e-05 0 1.05719999999996e-05 0 1.05720499999996e-05 0 1.05779999999996e-05 0 1.05780499999996e-05 0 1.05839999999996e-05 0 1.05840499999996e-05 0 1.05899999999996e-05 0 1.05900499999996e-05 0 1.05959999999996e-05 0 1.05960499999996e-05 0 1.06019999999996e-05 0 1.06020499999996e-05 0 1.06079999999996e-05 0 1.06080499999996e-05 0 1.06139999999996e-05 0 1.06140499999996e-05 0 1.06199999999996e-05 0 1.06200499999996e-05 0 1.06259999999996e-05 0 1.06260499999996e-05 0 1.06319999999996e-05 0 1.06320499999996e-05 0 1.06379999999996e-05 0 1.06380499999996e-05 0 1.06439999999996e-05 0 1.06440499999996e-05 0 1.06499999999996e-05 0 1.06500499999996e-05 0 1.06559999999996e-05 0 1.06560499999996e-05 0 1.06619999999996e-05 0 1.06620499999996e-05 0 1.06679999999996e-05 0 1.06680499999996e-05 0 1.06739999999996e-05 0 1.06740499999996e-05 0 1.06799999999996e-05 0 1.06800499999996e-05 0 1.06859999999996e-05 0 1.06860499999996e-05 0 1.06919999999996e-05 0 1.06920499999996e-05 0 1.06979999999996e-05 0 1.06980499999996e-05 0 1.07039999999996e-05 0 1.07040499999996e-05 0 1.07099999999996e-05 0 1.07100499999996e-05 0 1.07159999999996e-05 0 1.07160499999996e-05 0 1.07219999999996e-05 0 1.07220499999996e-05 0 1.07279999999996e-05 0 1.07280499999996e-05 0 1.07339999999996e-05 0 1.07340499999996e-05 0 1.07399999999996e-05 0 1.07400499999996e-05 0 1.07459999999996e-05 0 1.07460499999996e-05 0 1.07519999999996e-05 0 1.07520499999996e-05 0 1.07579999999996e-05 0 1.07580499999996e-05 0 1.07639999999996e-05 0 1.07640499999996e-05 0 1.07699999999996e-05 0 1.07700499999996e-05 0 1.07759999999996e-05 0 1.07760499999996e-05 0 1.07819999999996e-05 0 1.07820499999996e-05 0 1.07879999999996e-05 0 1.07880499999996e-05 0 1.07939999999996e-05 0 1.07940499999996e-05 0 1.07999999999996e-05 0 1.08000499999996e-05 0 1.08059999999996e-05 0 1.08060499999996e-05 0 1.08119999999996e-05 0 1.08120499999996e-05 0 1.08179999999996e-05 0 1.08180499999996e-05 0 1.08239999999996e-05 0 1.08240499999996e-05 0 1.08299999999996e-05 0 1.08300499999996e-05 0 1.08359999999996e-05 0 1.08360499999996e-05 0 1.08419999999996e-05 0 1.08420499999996e-05 0 1.08479999999996e-05 0 1.08480499999996e-05 0 1.08539999999996e-05 0 1.08540499999996e-05 0 1.08599999999996e-05 0 1.08600499999996e-05 0 1.08659999999996e-05 0 1.08660499999996e-05 0 1.08719999999996e-05 0 1.08720499999996e-05 0 1.08779999999996e-05 0 1.08780499999996e-05 0 1.08839999999996e-05 0 1.08840499999996e-05 0 1.08899999999996e-05 0 1.08900499999996e-05 0 1.08959999999996e-05 0 1.08960499999996e-05 0 1.09019999999996e-05 0 1.09020499999996e-05 0 1.09079999999996e-05 0 1.09080499999996e-05 0 1.09139999999996e-05 0 1.09140499999996e-05 0 1.09199999999996e-05 0 1.09200499999996e-05 0 1.09259999999996e-05 0 1.09260499999996e-05 0 1.09319999999996e-05 0 1.09320499999996e-05 0 1.09379999999996e-05 0 1.09380499999996e-05 0 1.09439999999996e-05 0 1.09440499999996e-05 0 1.09499999999996e-05 0 1.09500499999996e-05 0 1.09559999999996e-05 0 1.09560499999996e-05 0 1.09619999999996e-05 0 1.09620499999996e-05 0 1.09679999999996e-05 0 1.09680499999996e-05 0 1.09739999999996e-05 0 1.09740499999996e-05 0 1.09799999999996e-05 0 1.09800499999996e-05 0 1.09859999999996e-05 0 1.09860499999996e-05 0 1.09919999999996e-05 0 1.09920499999996e-05 0 1.09979999999996e-05 0 1.09980499999996e-05 0 1.10039999999996e-05 0 1.10040499999996e-05 0 1.10099999999996e-05 0 1.10100499999996e-05 0 1.10159999999996e-05 0 1.10160499999996e-05 0 1.10219999999996e-05 0 1.10220499999996e-05 0 1.10279999999996e-05 0 1.10280499999996e-05 0 1.10339999999996e-05 0 1.10340499999996e-05 0 1.10399999999996e-05 0 1.10400499999996e-05 0 1.10459999999996e-05 0 1.10460499999996e-05 0 1.10519999999996e-05 0 1.10520499999996e-05 0 1.10579999999996e-05 0 1.10580499999996e-05 0 1.10639999999996e-05 0 1.10640499999996e-05 0 1.10699999999996e-05 0 1.10700499999996e-05 0 1.10759999999996e-05 0 1.10760499999996e-05 0 1.10819999999996e-05 0 1.10820499999996e-05 0 1.10879999999996e-05 0 1.10880499999996e-05 0 1.10939999999996e-05 0 1.10940499999996e-05 0 1.10999999999996e-05 0 1.11000499999996e-05 0 1.11059999999996e-05 0 1.11060499999996e-05 0 1.11119999999996e-05 0 1.11120499999996e-05 0 1.11179999999996e-05 0 1.11180499999996e-05 0 1.11239999999996e-05 0 1.11240499999996e-05 0 1.11299999999996e-05 0 1.11300499999996e-05 0 1.11359999999996e-05 0 1.11360499999996e-05 0 1.11419999999996e-05 0 1.11420499999996e-05 0 1.11479999999996e-05 0 1.11480499999996e-05 0 1.11539999999996e-05 0 1.11540499999996e-05 0 1.11599999999996e-05 0 1.11600499999996e-05 0 1.11659999999996e-05 0 1.11660499999996e-05 0 1.11719999999996e-05 0 1.11720499999996e-05 0 1.11779999999996e-05 0 1.11780499999996e-05 0 1.11839999999996e-05 0 1.11840499999996e-05 0 1.11899999999996e-05 0 1.11900499999996e-05 0 1.11959999999996e-05 0 1.11960499999996e-05 0 1.12019999999996e-05 0 1.12020499999996e-05 0 1.12079999999996e-05 0 1.12080499999996e-05 0 1.12139999999996e-05 0 1.12140499999996e-05 0 1.12199999999996e-05 0 1.12200499999996e-05 0 1.12259999999996e-05 0 1.12260499999996e-05 0 1.12319999999996e-05 0 1.12320499999996e-05 0 1.12379999999996e-05 0 1.12380499999996e-05 0 1.12439999999996e-05 0 1.12440499999996e-05 0 1.12499999999996e-05 0 1.12500499999996e-05 0 1.12559999999995e-05 0 1.12560499999995e-05 0 1.12619999999995e-05 0 1.12620499999995e-05 0 1.12679999999995e-05 0 1.12680499999995e-05 0 1.12739999999995e-05 0 1.12740499999995e-05 0 1.12799999999995e-05 0 1.12800499999995e-05 0 1.12859999999995e-05 0 1.12860499999995e-05 0 1.12919999999995e-05 0 1.12920499999995e-05 0 1.12979999999995e-05 0 1.12980499999995e-05 0 1.13039999999995e-05 0 1.13040499999995e-05 0 1.13099999999995e-05 0 1.13100499999995e-05 0 1.13159999999995e-05 0 1.13160499999995e-05 0 1.13219999999995e-05 0 1.13220499999995e-05 0 1.13279999999995e-05 0 1.13280499999995e-05 0 1.13339999999995e-05 0 1.13340499999995e-05 0 1.13399999999995e-05 0 1.13400499999995e-05 0 1.13459999999995e-05 0 1.13460499999995e-05 0 1.13519999999995e-05 0 1.13520499999995e-05 0 1.13579999999995e-05 0 1.13580499999995e-05 0 1.13639999999995e-05 0 1.13640499999995e-05 0 1.13699999999995e-05 0 1.13700499999995e-05 0 1.13759999999995e-05 0 1.13760499999995e-05 0 1.13819999999995e-05 0 1.13820499999995e-05 0 1.13879999999995e-05 0 1.13880499999995e-05 0 1.13939999999995e-05 0 1.13940499999995e-05 0 1.13999999999995e-05 0 1.14000499999995e-05 0 1.14059999999995e-05 0 1.14060499999995e-05 0 1.14119999999995e-05 0 1.14120499999995e-05 0 1.14179999999995e-05 0 1.14180499999995e-05 0 1.14239999999995e-05 0 1.14240499999995e-05 0 1.14299999999995e-05 0 1.14300499999995e-05 0 1.14359999999995e-05 0 1.14360499999995e-05 0 1.14419999999995e-05 0 1.14420499999995e-05 0 1.14479999999995e-05 0 1.14480499999995e-05 0 1.14539999999995e-05 0 1.14540499999995e-05 0 1.14599999999995e-05 0 1.14600499999995e-05 0 1.14659999999995e-05 0 1.14660499999995e-05 0 1.14719999999995e-05 0 1.14720499999995e-05 0 1.14779999999995e-05 0 1.14780499999995e-05 0 1.14839999999995e-05 0 1.14840499999995e-05 0 1.14899999999995e-05 0 1.14900499999995e-05 0 1.14959999999995e-05 0 1.14960499999995e-05 0 1.15019999999995e-05 0 1.15020499999995e-05 0 1.15079999999995e-05 0 1.15080499999995e-05 0 1.15139999999995e-05 0 1.15140499999995e-05 0 1.15199999999995e-05 0 1.15200499999995e-05 0 1.15259999999995e-05 0 1.15260499999995e-05 0 1.15319999999995e-05 0 1.15320499999995e-05 0 1.15379999999995e-05 0 1.15380499999995e-05 0 1.15439999999995e-05 0 1.15440499999995e-05 0 1.15499999999995e-05 0 1.15500499999995e-05 0 1.15559999999995e-05 0 1.15560499999995e-05 0 1.15619999999995e-05 0 1.15620499999995e-05 0 1.15679999999995e-05 0 1.15680499999995e-05 0 1.15739999999995e-05 0 1.15740499999995e-05 0 1.15799999999995e-05 0 1.15800499999995e-05 0 1.15859999999995e-05 0 1.15860499999995e-05 0 1.15919999999995e-05 0 1.15920499999995e-05 0 1.15979999999995e-05 0 1.15980499999995e-05 0 1.16039999999995e-05 0 1.16040499999995e-05 0 1.16099999999995e-05 0 1.16100499999995e-05 0 1.16159999999995e-05 0 1.16160499999995e-05 0 1.16219999999995e-05 0 1.16220499999995e-05 0 1.16279999999995e-05 0 1.16280499999995e-05 0 1.16339999999995e-05 0 1.16340499999995e-05 0 1.16399999999995e-05 0 1.16400499999995e-05 0 1.16459999999995e-05 0 1.16460499999995e-05 0 1.16519999999995e-05 0 1.16520499999995e-05 0 1.16579999999995e-05 0 1.16580499999995e-05 0 1.16639999999995e-05 0 1.16640499999995e-05 0 1.16699999999995e-05 0 1.16700499999995e-05 0 1.16759999999995e-05 0 1.16760499999995e-05 0 1.16819999999995e-05 0 1.16820499999995e-05 0 1.16879999999995e-05 0 1.16880499999995e-05 0 1.16939999999995e-05 0 1.16940499999995e-05 0 1.16999999999995e-05 0 1.17000499999995e-05 0 1.17059999999995e-05 0 1.17060499999995e-05 0 1.17119999999995e-05 0 1.17120499999995e-05 0 1.17179999999995e-05 0 1.17180499999995e-05 0 1.17239999999995e-05 0 1.17240499999995e-05 0 1.17299999999995e-05 0 1.17300499999995e-05 0 1.17359999999995e-05 0 1.17360499999995e-05 0 1.17419999999995e-05 0 1.17420499999995e-05 0 1.17479999999995e-05 0 1.17480499999995e-05 0 1.17539999999995e-05 0 1.17540499999995e-05 0 1.17599999999995e-05 0 1.17600499999995e-05 0 1.17659999999995e-05 0 1.17660499999995e-05 0 1.17719999999995e-05 0 1.17720499999995e-05 0 1.17779999999995e-05 0 1.17780499999995e-05 0 1.17839999999995e-05 0 1.17840499999995e-05 0 1.17899999999995e-05 0 1.17900499999995e-05 0 1.17959999999995e-05 0 1.17960499999995e-05 0 1.18019999999995e-05 0 1.18020499999995e-05 0 1.18079999999995e-05 0 1.18080499999995e-05 0 1.18139999999995e-05 0 1.18140499999995e-05 0 1.18199999999995e-05 0 1.18200499999995e-05 0 1.18259999999995e-05 0 1.18260499999995e-05 0 1.18319999999995e-05 0 1.18320499999995e-05 0 1.18379999999995e-05 0 1.18380499999995e-05 0 1.18439999999995e-05 0 1.18440499999995e-05 0 1.18499999999995e-05 0 1.18500499999995e-05 0 1.18559999999995e-05 0 1.18560499999995e-05 0 1.18619999999995e-05 0 1.18620499999995e-05 0 1.18679999999995e-05 0 1.18680499999995e-05 0 1.18739999999995e-05 0 1.18740499999995e-05 0 1.18799999999995e-05 0 1.18800499999995e-05 0 1.18859999999995e-05 0 1.18860499999995e-05 0 1.18919999999995e-05 0 1.18920499999995e-05 0 1.18979999999995e-05 0 1.18980499999995e-05 0 1.19039999999995e-05 0 1.19040499999995e-05 0 1.19099999999995e-05 0 1.19100499999995e-05 0 1.19159999999995e-05 0 1.19160499999995e-05 0 1.19219999999995e-05 0 1.19220499999995e-05 0 1.19279999999995e-05 0 1.19280499999995e-05 0 1.19339999999995e-05 0 1.19340499999995e-05 0 1.19399999999995e-05 0 1.19400499999995e-05 0 1.19459999999995e-05 0 1.19460499999995e-05 0 1.19519999999995e-05 0 1.19520499999995e-05 0 1.19579999999995e-05 0 1.19580499999995e-05 0 1.19639999999995e-05 0 1.19640499999995e-05 0 1.19699999999995e-05 0 1.19700499999995e-05 0 1.19759999999995e-05 0 1.19760499999995e-05 0 1.19819999999995e-05 0 1.19820499999995e-05 0 1.19879999999995e-05 0 1.19880499999995e-05 0 1.19939999999995e-05 0 1.19940499999995e-05 0 1.19999999999995e-05 0 1.20000499999995e-05 0 1.20059999999995e-05 0 1.20060499999995e-05 0 1.20119999999995e-05 0 1.20120499999995e-05 0 1.20179999999995e-05 0 1.20180499999995e-05 0 1.20239999999995e-05 0 1.20240499999995e-05 0 1.20299999999995e-05 0 1.20300499999995e-05 0 1.20359999999995e-05 0 1.20360499999995e-05 0 1.20419999999995e-05 0 1.20420499999995e-05 0 1.20479999999995e-05 0 1.20480499999995e-05 0 1.20539999999995e-05 0 1.20540499999995e-05 0 1.20599999999995e-05 0 1.20600499999995e-05 0 1.20659999999995e-05 0 1.20660499999995e-05 0 1.20719999999995e-05 0 1.20720499999995e-05 0 1.20779999999995e-05 0 1.20780499999995e-05 0 1.20839999999995e-05 0 1.20840499999995e-05 0 1.20899999999995e-05 0 1.20900499999995e-05 0 1.20959999999995e-05 0 1.20960499999995e-05 0 1.21019999999995e-05 0 1.21020499999995e-05 0 1.21079999999995e-05 0 1.21080499999995e-05 0 1.21139999999995e-05 0 1.21140499999995e-05 0 1.21199999999995e-05 0 1.21200499999995e-05 0 1.21259999999995e-05 0 1.21260499999995e-05 0 1.21319999999995e-05 0 1.21320499999995e-05 0 1.21379999999995e-05 0 1.21380499999995e-05 0 1.21439999999995e-05 0 1.21440499999995e-05 0 1.21499999999995e-05 0 1.21500499999995e-05 0 1.21559999999995e-05 0 1.21560499999995e-05 0 1.21619999999995e-05 0 1.21620499999995e-05 0 1.21679999999995e-05 0 1.21680499999995e-05 0 1.21739999999995e-05 0 1.21740499999995e-05 0 1.21799999999995e-05 0 1.21800499999995e-05 0 1.21859999999995e-05 0 1.21860499999995e-05 0 1.21919999999995e-05 0 1.21920499999995e-05 0 1.21979999999995e-05 0 1.21980499999995e-05 0 1.22039999999995e-05 0 1.22040499999995e-05 0 1.22099999999995e-05 0 1.22100499999995e-05 0 1.22159999999995e-05 0 1.22160499999995e-05 0 1.22219999999995e-05 0 1.22220499999995e-05 0 1.22279999999995e-05 0 1.22280499999995e-05 0 1.22339999999995e-05 0 1.22340499999995e-05 0 1.22399999999995e-05 0 1.22400499999995e-05 0 1.22459999999995e-05 0 1.22460499999995e-05 0 1.22519999999995e-05 0 1.22520499999995e-05 0 1.22579999999995e-05 0 1.22580499999995e-05 0 1.22639999999995e-05 0 1.22640499999995e-05 0 1.22699999999995e-05 0 1.22700499999995e-05 0 1.22759999999995e-05 0 1.22760499999995e-05 0 1.22819999999995e-05 0 1.22820499999995e-05 0 1.22874999999995e-05 0]
