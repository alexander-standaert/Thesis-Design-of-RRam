simulator lang=spectre

parameters vdd = 1

parameters PWmin = 100n                         //MinimalTransistorWidth
parameters PLmin = 45n                          //MinimalTransistorLenght
parameters WChargeBL = 3e-07         //BitLineChargerWidth(perBL)
parameters LChargeBL = 1.95e-07
parameters WDischargeBL = 1e-07   //BitLineDischargerWidth(perBL)
parameters WDischargeSL = 5e-07   //SourceLineDischargerWidth(perBL)
parameters Cpar = 0.18e-15                      //ParasiticCapacitor(perCell)
parameters PWn = 2e-07                     //DifferentialNpairWidth(perSA)
parameters PWp = 4e-07                     //DifferentialPpairWidth(perSA)
parameters PWpenable = 5e-07         //SenseAmpEnablePWidth(perSA)
parameters PWnenable = 5e-07         //SenseAmpEnableNWidth(perSA)
parameters PWmuxLB = 2e-07                //PassgateWidth(perMuxLB)
parameters PWmuxGB = 2e-07                //PassgateWidth(perMuxGB)

parameters numberofruns = 1
parameters enableMismatch = 0   //Mismatch
parameters simlength = 1.8e-08

parameters RMEMHigh = 32500;
parameters RMEMLow = 7500;

parameters Rcell_0_0_0_0 = RMEMHigh
parameters Rcell_0_0_0_1 = RMEMHigh
parameters Rcell_0_0_0_2 = RMEMHigh
parameters Rcell_0_0_0_3 = RMEMHigh
parameters Rcell_0_0_0_4 = RMEMLow
parameters Rcell_0_0_0_5 = RMEMLow
parameters Rcell_0_0_0_6 = RMEMLow
parameters Rcell_0_0_0_7 = RMEMLow
parameters Rcell_0_0_0_8 = RMEMLow
parameters Rcell_0_0_0_9 = RMEMLow
parameters Rcell_0_0_0_10 = RMEMLow
parameters Rcell_0_0_0_11 = RMEMHigh
parameters Rcell_0_0_0_12 = RMEMHigh
parameters Rcell_0_0_0_13 = RMEMHigh
parameters Rcell_0_0_0_14 = RMEMHigh
parameters Rcell_0_0_0_15 = RMEMHigh
parameters Rcell_0_0_1_0 = RMEMLow
parameters Rcell_0_0_1_1 = RMEMLow
parameters Rcell_0_0_1_2 = RMEMHigh
parameters Rcell_0_0_1_3 = RMEMLow
parameters Rcell_0_0_1_4 = RMEMHigh
parameters Rcell_0_0_1_5 = RMEMHigh
parameters Rcell_0_0_1_6 = RMEMHigh
parameters Rcell_0_0_1_7 = RMEMLow
parameters Rcell_0_0_1_8 = RMEMLow
parameters Rcell_0_0_1_9 = RMEMHigh
parameters Rcell_0_0_1_10 = RMEMHigh
parameters Rcell_0_0_1_11 = RMEMHigh
parameters Rcell_0_0_1_12 = RMEMLow
parameters Rcell_0_0_1_13 = RMEMLow
parameters Rcell_0_0_1_14 = RMEMHigh
parameters Rcell_0_0_1_15 = RMEMLow
parameters Rcell_0_0_2_0 = RMEMLow
parameters Rcell_0_0_2_1 = RMEMHigh
parameters Rcell_0_0_2_2 = RMEMLow
parameters Rcell_0_0_2_3 = RMEMLow
parameters Rcell_0_0_2_4 = RMEMHigh
parameters Rcell_0_0_2_5 = RMEMLow
parameters Rcell_0_0_2_6 = RMEMHigh
parameters Rcell_0_0_2_7 = RMEMLow
parameters Rcell_0_0_2_8 = RMEMHigh
parameters Rcell_0_0_2_9 = RMEMHigh
parameters Rcell_0_0_2_10 = RMEMLow
parameters Rcell_0_0_2_11 = RMEMLow
parameters Rcell_0_0_2_12 = RMEMLow
parameters Rcell_0_0_2_13 = RMEMLow
parameters Rcell_0_0_2_14 = RMEMLow
parameters Rcell_0_0_2_15 = RMEMLow
parameters Rcell_0_0_3_0 = RMEMHigh
parameters Rcell_0_0_3_1 = RMEMLow
parameters Rcell_0_0_3_2 = RMEMHigh
parameters Rcell_0_0_3_3 = RMEMLow
parameters Rcell_0_0_3_4 = RMEMHigh
parameters Rcell_0_0_3_5 = RMEMLow
parameters Rcell_0_0_3_6 = RMEMHigh
parameters Rcell_0_0_3_7 = RMEMHigh
parameters Rcell_0_0_3_8 = RMEMLow
parameters Rcell_0_0_3_9 = RMEMLow
parameters Rcell_0_0_3_10 = RMEMHigh
parameters Rcell_0_0_3_11 = RMEMHigh
parameters Rcell_0_0_3_12 = RMEMLow
parameters Rcell_0_0_3_13 = RMEMHigh
parameters Rcell_0_0_3_14 = RMEMLow
parameters Rcell_0_0_3_15 = RMEMHigh
parameters Rcell_0_1_0_0 = RMEMHigh
parameters Rcell_0_1_0_1 = RMEMLow
parameters Rcell_0_1_0_2 = RMEMHigh
parameters Rcell_0_1_0_3 = RMEMHigh
parameters Rcell_0_1_0_4 = RMEMHigh
parameters Rcell_0_1_0_5 = RMEMHigh
parameters Rcell_0_1_0_6 = RMEMHigh
parameters Rcell_0_1_0_7 = RMEMLow
parameters Rcell_0_1_0_8 = RMEMLow
parameters Rcell_0_1_0_9 = RMEMLow
parameters Rcell_0_1_0_10 = RMEMHigh
parameters Rcell_0_1_0_11 = RMEMHigh
parameters Rcell_0_1_0_12 = RMEMHigh
parameters Rcell_0_1_0_13 = RMEMLow
parameters Rcell_0_1_0_14 = RMEMHigh
parameters Rcell_0_1_0_15 = RMEMLow
parameters Rcell_0_1_1_0 = RMEMLow
parameters Rcell_0_1_1_1 = RMEMLow
parameters Rcell_0_1_1_2 = RMEMHigh
parameters Rcell_0_1_1_3 = RMEMLow
parameters Rcell_0_1_1_4 = RMEMLow
parameters Rcell_0_1_1_5 = RMEMLow
parameters Rcell_0_1_1_6 = RMEMLow
parameters Rcell_0_1_1_7 = RMEMLow
parameters Rcell_0_1_1_8 = RMEMHigh
parameters Rcell_0_1_1_9 = RMEMHigh
parameters Rcell_0_1_1_10 = RMEMHigh
parameters Rcell_0_1_1_11 = RMEMHigh
parameters Rcell_0_1_1_12 = RMEMHigh
parameters Rcell_0_1_1_13 = RMEMHigh
parameters Rcell_0_1_1_14 = RMEMHigh
parameters Rcell_0_1_1_15 = RMEMHigh
parameters Rcell_0_1_2_0 = RMEMLow
parameters Rcell_0_1_2_1 = RMEMHigh
parameters Rcell_0_1_2_2 = RMEMHigh
parameters Rcell_0_1_2_3 = RMEMHigh
parameters Rcell_0_1_2_4 = RMEMHigh
parameters Rcell_0_1_2_5 = RMEMLow
parameters Rcell_0_1_2_6 = RMEMHigh
parameters Rcell_0_1_2_7 = RMEMLow
parameters Rcell_0_1_2_8 = RMEMLow
parameters Rcell_0_1_2_9 = RMEMHigh
parameters Rcell_0_1_2_10 = RMEMHigh
parameters Rcell_0_1_2_11 = RMEMHigh
parameters Rcell_0_1_2_12 = RMEMHigh
parameters Rcell_0_1_2_13 = RMEMHigh
parameters Rcell_0_1_2_14 = RMEMLow
parameters Rcell_0_1_2_15 = RMEMHigh
parameters Rcell_0_1_3_0 = RMEMLow
parameters Rcell_0_1_3_1 = RMEMHigh
parameters Rcell_0_1_3_2 = RMEMHigh
parameters Rcell_0_1_3_3 = RMEMHigh
parameters Rcell_0_1_3_4 = RMEMHigh
parameters Rcell_0_1_3_5 = RMEMHigh
parameters Rcell_0_1_3_6 = RMEMHigh
parameters Rcell_0_1_3_7 = RMEMHigh
parameters Rcell_0_1_3_8 = RMEMHigh
parameters Rcell_0_1_3_9 = RMEMHigh
parameters Rcell_0_1_3_10 = RMEMLow
parameters Rcell_0_1_3_11 = RMEMLow
parameters Rcell_0_1_3_12 = RMEMHigh
parameters Rcell_0_1_3_13 = RMEMLow
parameters Rcell_0_1_3_14 = RMEMHigh
parameters Rcell_0_1_3_15 = RMEMLow

parameters Rref_0 = RMEMHigh
parameters Rref_2 = RMEMHigh
parameters Rref_1 = RMEMLow
parameters Rref_3 = RMEMLow

parameters waveEnGB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveEnLB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63049999999997e-07 0 7.66999999999997e-07 0 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveEnLB_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveBLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveBLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveWLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveWLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveWLstart_2=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters waveWLstart_3=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.72499999999997e-07 0]
parameters wave_SA_SH = [0 0 3e-09 0 3.1e-09 1 4e-09 1 4.05e-09 0 6e-09 0 6.05e-09 0 9e-09 0 9.1e-09 1 1e-08 1 1.005e-08 0 1.2e-08 0 1.205e-08 0 1.5e-08 0 1.51e-08 1 1.6e-08 1 1.605e-08 0 1.8e-08 0 1.805e-08 0 2.1e-08 0 2.11e-08 1 2.2e-08 1 2.205e-08 0 2.4e-08 0 2.405e-08 0 2.7e-08 0 2.71e-08 1 2.8e-08 1 2.805e-08 0 3e-08 0 3.005e-08 0 3.3e-08 0 3.31e-08 1 3.4e-08 1 3.405e-08 0 3.6e-08 0 3.605e-08 0 3.9e-08 0 3.91e-08 1 4e-08 1 4.005e-08 0 4.2e-08 0 4.205e-08 0 4.5e-08 0 4.51e-08 1 4.6e-08 1 4.605e-08 0 4.8e-08 0 4.805e-08 0 5.1e-08 0 5.11e-08 1 5.2e-08 1 5.205e-08 0 5.4e-08 0 5.405e-08 0 5.7e-08 0 5.71e-08 1 5.8e-08 1 5.805e-08 0 6e-08 0 6.005e-08 0 6.3e-08 0 6.31e-08 1 6.4e-08 1 6.405e-08 0 6.6e-08 0 6.605e-08 0 6.9e-08 0 6.91e-08 1 7e-08 1 7.005e-08 0 7.2e-08 0 7.205e-08 0 7.5e-08 0 7.51e-08 1 7.6e-08 1 7.605e-08 0 7.8e-08 0 7.805e-08 0 8.1e-08 0 8.11e-08 1 8.2e-08 1 8.205e-08 0 8.4e-08 0 8.405e-08 0 8.7e-08 0 8.71e-08 1 8.8e-08 1 8.805e-08 0 9e-08 0 9.005e-08 0 9.3e-08 0 9.31e-08 1 9.4e-08 1 9.405e-08 0 9.6e-08 0 9.605e-08 0 9.9e-08 0 9.91e-08 1 1e-07 1 1.0005e-07 0 1.02e-07 0 1.0205e-07 0 1.05e-07 0 1.051e-07 1 1.06e-07 1 1.0605e-07 0 1.08e-07 0 1.0805e-07 0 1.11e-07 0 1.111e-07 1 1.12e-07 1 1.1205e-07 0 1.14e-07 0 1.1405e-07 0 1.17e-07 0 1.171e-07 1 1.18e-07 1 1.1805e-07 0 1.2e-07 0 1.2005e-07 0 1.23e-07 0 1.231e-07 1 1.24e-07 1 1.2405e-07 0 1.26e-07 0 1.2605e-07 0 1.29e-07 0 1.291e-07 1 1.3e-07 1 1.3005e-07 0 1.32e-07 0 1.3205e-07 0 1.35e-07 0 1.351e-07 1 1.36e-07 1 1.3605e-07 0 1.38e-07 0 1.3805e-07 0 1.41e-07 0 1.411e-07 1 1.42e-07 1 1.4205e-07 0 1.44e-07 0 1.4405e-07 0 1.47e-07 0 1.471e-07 1 1.48e-07 1 1.4805e-07 0 1.5e-07 0 1.5005e-07 0 1.53e-07 0 1.531e-07 1 1.54e-07 1 1.5405e-07 0 1.56e-07 0 1.5605e-07 0 1.59e-07 0 1.591e-07 1 1.6e-07 1 1.6005e-07 0 1.62e-07 0 1.6205e-07 0 1.65e-07 0 1.651e-07 1 1.66e-07 1 1.6605e-07 0 1.68e-07 0 1.6805e-07 0 1.71e-07 0 1.711e-07 1 1.72e-07 1 1.7205e-07 0 1.74e-07 0 1.7405e-07 0 1.77e-07 0 1.771e-07 1 1.78e-07 1 1.7805e-07 0 1.8e-07 0 1.8005e-07 0 1.83e-07 0 1.831e-07 1 1.84e-07 1 1.8405e-07 0 1.86e-07 0 1.8605e-07 0 1.89e-07 0 1.891e-07 1 1.9e-07 1 1.9005e-07 0 1.92e-07 0 1.9205e-07 0 1.95e-07 0 1.951e-07 1 1.96e-07 1 1.9605e-07 0 1.98e-07 0 1.9805e-07 0 2.01e-07 0 2.011e-07 1 2.02e-07 1 2.0205e-07 0 2.04e-07 0 2.0405e-07 0 2.07e-07 0 2.071e-07 1 2.08e-07 1 2.0805e-07 0 2.1e-07 0 2.1005e-07 0 2.13e-07 0 2.131e-07 1 2.14e-07 1 2.1405e-07 0 2.16e-07 0 2.1605e-07 0 2.19e-07 0 2.191e-07 1 2.2e-07 1 2.2005e-07 0 2.22e-07 0 2.2205e-07 0 2.25e-07 0 2.251e-07 1 2.26e-07 1 2.2605e-07 0 2.28e-07 0 2.2805e-07 0 2.31e-07 0 2.311e-07 1 2.32e-07 1 2.3205e-07 0 2.34e-07 0 2.3405e-07 0 2.37e-07 0 2.371e-07 1 2.38e-07 1 2.3805e-07 0 2.4e-07 0 2.4005e-07 0 2.43e-07 0 2.431e-07 1 2.44e-07 1 2.4405e-07 0 2.46e-07 0 2.4605e-07 0 2.49e-07 0 2.491e-07 1 2.5e-07 1 2.5005e-07 0 2.52e-07 0 2.5205e-07 0 2.55e-07 0 2.551e-07 1 2.56e-07 1 2.5605e-07 0 2.58e-07 0 2.5805e-07 0 2.61e-07 0 2.611e-07 1 2.62e-07 1 2.6205e-07 0 2.64e-07 0 2.6405e-07 0 2.67e-07 0 2.671e-07 1 2.68e-07 1 2.6805e-07 0 2.7e-07 0 2.7005e-07 0 2.73e-07 0 2.731e-07 1 2.74e-07 1 2.7405e-07 0 2.76e-07 0 2.7605e-07 0 2.79e-07 0 2.791e-07 1 2.8e-07 1 2.8005e-07 0 2.82e-07 0 2.8205e-07 0 2.85e-07 0 2.851e-07 1 2.86e-07 1 2.8605e-07 0 2.88e-07 0 2.8805e-07 0 2.91e-07 0 2.911e-07 1 2.92e-07 1 2.9205e-07 0 2.94e-07 0 2.9405e-07 0 2.97e-07 0 2.971e-07 1 2.98e-07 1 2.9805e-07 0 3e-07 0 3.0005e-07 0 3.03e-07 0 3.031e-07 1 3.04e-07 1 3.0405e-07 0 3.06e-07 0 3.0605e-07 0 3.09e-07 0 3.091e-07 1 3.1e-07 1 3.1005e-07 0 3.12e-07 0 3.1205e-07 0 3.15e-07 0 3.151e-07 1 3.16e-07 1 3.1605e-07 0 3.18e-07 0 3.1805e-07 0 3.21e-07 0 3.211e-07 1 3.22e-07 1 3.2205e-07 0 3.24e-07 0 3.2405e-07 0 3.27e-07 0 3.271e-07 1 3.28e-07 1 3.2805e-07 0 3.3e-07 0 3.3005e-07 0 3.33e-07 0 3.331e-07 1 3.34e-07 1 3.3405e-07 0 3.36e-07 0 3.3605e-07 0 3.39e-07 0 3.391e-07 1 3.4e-07 1 3.4005e-07 0 3.42e-07 0 3.4205e-07 0 3.45e-07 0 3.451e-07 1 3.46e-07 1 3.4605e-07 0 3.48e-07 0 3.4805e-07 0 3.51e-07 0 3.511e-07 1 3.52e-07 1 3.5205e-07 0 3.54e-07 0 3.5405e-07 0 3.57e-07 0 3.571e-07 1 3.58e-07 1 3.5805e-07 0 3.6e-07 0 3.6005e-07 0 3.63e-07 0 3.631e-07 1 3.64e-07 1 3.6405e-07 0 3.66e-07 0 3.6605e-07 0 3.69e-07 0 3.691e-07 1 3.7e-07 1 3.7005e-07 0 3.72e-07 0 3.7205e-07 0 3.75e-07 0 3.751e-07 1 3.76e-07 1 3.7605e-07 0 3.78e-07 0 3.7805e-07 0 3.81e-07 0 3.811e-07 1 3.82e-07 1 3.8205e-07 0 3.84e-07 0 3.8405e-07 0 3.87e-07 0 3.871e-07 1 3.88e-07 1 3.8805e-07 0 3.9e-07 0 3.9005e-07 0 3.93e-07 0 3.931e-07 1 3.94e-07 1 3.9405e-07 0 3.96e-07 0 3.9605e-07 0 3.99e-07 0 3.991e-07 1 4e-07 1 4.0005e-07 0 4.02e-07 0 4.0205e-07 0 4.05e-07 0 4.051e-07 1 4.06e-07 1 4.0605e-07 0 4.08e-07 0 4.0805e-07 0 4.11e-07 0 4.111e-07 1 4.12e-07 1 4.1205e-07 0 4.14e-07 0 4.1405e-07 0 4.17e-07 0 4.171e-07 1 4.18e-07 1 4.1805e-07 0 4.2e-07 0 4.2005e-07 0 4.23e-07 0 4.231e-07 1 4.24e-07 1 4.2405e-07 0 4.26e-07 0 4.2605e-07 0 4.29e-07 0 4.291e-07 1 4.3e-07 1 4.3005e-07 0 4.32e-07 0 4.3205e-07 0 4.35e-07 0 4.351e-07 1 4.36e-07 1 4.3605e-07 0 4.38e-07 0 4.3805e-07 0 4.41e-07 0 4.411e-07 1 4.42e-07 1 4.4205e-07 0 4.44e-07 0 4.4405e-07 0 4.47e-07 0 4.47100000000001e-07 1 4.48000000000001e-07 1 4.48050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.53000000000001e-07 0 4.53100000000001e-07 1 4.54000000000001e-07 1 4.54050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.59000000000001e-07 0 4.59100000000001e-07 1 4.60000000000001e-07 1 4.60050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.65000000000001e-07 0 4.65100000000001e-07 1 4.66000000000001e-07 1 4.66050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.71000000000001e-07 0 4.71100000000001e-07 1 4.72000000000001e-07 1 4.72050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.77000000000001e-07 0 4.77100000000001e-07 1 4.78000000000001e-07 1 4.78050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.83000000000001e-07 0 4.83100000000001e-07 1 4.84000000000001e-07 1 4.84050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.89000000000001e-07 0 4.89100000000001e-07 1 4.90000000000001e-07 1 4.90050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.95000000000001e-07 0 4.95100000000001e-07 1 4.96000000000001e-07 1 4.96050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 5.01000000000001e-07 0 5.01100000000001e-07 1 5.02000000000001e-07 1 5.02050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.07000000000001e-07 0 5.07100000000001e-07 1 5.08000000000001e-07 1 5.08050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.13000000000001e-07 0 5.13100000000001e-07 1 5.14000000000001e-07 1 5.14050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.19000000000001e-07 0 5.19100000000001e-07 1 5.20000000000001e-07 1 5.20050000000001e-07 0 5.22000000000001e-07 0 5.22050000000001e-07 0 5.25000000000001e-07 0 5.25100000000001e-07 1 5.26000000000001e-07 1 5.26050000000001e-07 0 5.28000000000001e-07 0 5.28050000000001e-07 0 5.31000000000001e-07 0 5.31100000000001e-07 1 5.32000000000001e-07 1 5.32050000000001e-07 0 5.34000000000001e-07 0 5.34050000000001e-07 0 5.37000000000001e-07 0 5.37100000000001e-07 1 5.38000000000001e-07 1 5.38050000000001e-07 0 5.40000000000001e-07 0 5.40050000000001e-07 0 5.43000000000001e-07 0 5.43100000000001e-07 1 5.44000000000001e-07 1 5.44050000000001e-07 0 5.46000000000001e-07 0 5.46050000000001e-07 0 5.49000000000001e-07 0 5.49100000000001e-07 1 5.50000000000001e-07 1 5.50050000000001e-07 0 5.52000000000001e-07 0 5.52050000000001e-07 0 5.55000000000001e-07 0 5.55100000000001e-07 1 5.56000000000001e-07 1 5.56050000000001e-07 0 5.58000000000001e-07 0 5.58050000000001e-07 0 5.61000000000001e-07 0 5.61100000000001e-07 1 5.62000000000001e-07 1 5.62050000000001e-07 0 5.64000000000001e-07 0 5.64050000000001e-07 0 5.67000000000001e-07 0 5.67100000000001e-07 1 5.68000000000001e-07 1 5.68050000000001e-07 0 5.70000000000001e-07 0 5.70050000000001e-07 0 5.73000000000001e-07 0 5.73100000000001e-07 1 5.74000000000001e-07 1 5.74050000000001e-07 0 5.76000000000001e-07 0 5.76050000000001e-07 0 5.79000000000001e-07 0 5.79100000000001e-07 1 5.80000000000001e-07 1 5.80050000000001e-07 0 5.82000000000001e-07 0 5.82050000000001e-07 0 5.85000000000001e-07 0 5.85100000000001e-07 1 5.86000000000001e-07 1 5.86050000000001e-07 0 5.88000000000001e-07 0 5.88050000000001e-07 0 5.91000000000001e-07 0 5.91100000000001e-07 1 5.92000000000001e-07 1 5.92050000000001e-07 0 5.94000000000001e-07 0 5.94050000000001e-07 0 5.97000000000001e-07 0 5.97100000000001e-07 1 5.98000000000001e-07 1 5.98050000000001e-07 0 6.00000000000001e-07 0 6.00050000000001e-07 0 6.03000000000001e-07 0 6.03100000000001e-07 1 6.04000000000001e-07 1 6.04050000000001e-07 0 6.06000000000001e-07 0 6.06050000000001e-07 0 6.09000000000001e-07 0 6.09100000000001e-07 1 6.10000000000001e-07 1 6.10050000000001e-07 0 6.12000000000001e-07 0 6.12050000000001e-07 0 6.15000000000001e-07 0 6.15100000000001e-07 1 6.16000000000001e-07 1 6.16050000000001e-07 0 6.18000000000001e-07 0 6.18050000000001e-07 0 6.21000000000001e-07 0 6.21100000000001e-07 1 6.22000000000001e-07 1 6.22050000000001e-07 0 6.24000000000001e-07 0 6.24050000000001e-07 0 6.27000000000001e-07 0 6.27100000000001e-07 1 6.28000000000001e-07 1 6.28050000000001e-07 0 6.30000000000001e-07 0 6.30050000000001e-07 0 6.33000000000001e-07 0 6.33100000000001e-07 1 6.34000000000001e-07 1 6.34050000000001e-07 0 6.36000000000001e-07 0 6.36050000000001e-07 0 6.39000000000001e-07 0 6.39100000000001e-07 1 6.40000000000001e-07 1 6.40050000000001e-07 0 6.42000000000001e-07 0 6.42050000000001e-07 0 6.45000000000001e-07 0 6.45100000000001e-07 1 6.46000000000001e-07 1 6.46050000000001e-07 0 6.48000000000001e-07 0 6.48050000000001e-07 0 6.51000000000001e-07 0 6.51100000000001e-07 1 6.52000000000001e-07 1 6.52050000000001e-07 0 6.54000000000001e-07 0 6.54050000000001e-07 0 6.57000000000001e-07 0 6.57100000000001e-07 1 6.58000000000001e-07 1 6.58050000000001e-07 0 6.60000000000001e-07 0 6.60050000000001e-07 0 6.63000000000001e-07 0 6.63100000000001e-07 1 6.64000000000001e-07 1 6.64050000000001e-07 0 6.66000000000001e-07 0 6.66050000000001e-07 0 6.69000000000001e-07 0 6.69100000000001e-07 1 6.70000000000001e-07 1 6.70050000000001e-07 0 6.72000000000001e-07 0 6.72050000000001e-07 0 6.75000000000001e-07 0 6.75100000000001e-07 1 6.76000000000001e-07 1 6.76050000000001e-07 0 6.78000000000001e-07 0 6.78050000000001e-07 0 6.81000000000002e-07 0 6.81100000000002e-07 1 6.82000000000001e-07 1 6.82050000000001e-07 0 6.84000000000002e-07 0 6.84050000000002e-07 0 6.87000000000002e-07 0 6.87100000000002e-07 1 6.88000000000002e-07 1 6.88050000000002e-07 0 6.90000000000002e-07 0 6.90050000000002e-07 0 6.93000000000002e-07 0 6.93100000000002e-07 1 6.94000000000002e-07 1 6.94050000000002e-07 0 6.96000000000002e-07 0 6.96050000000002e-07 0 6.99000000000002e-07 0 6.99100000000002e-07 1 7.00000000000002e-07 1 7.00050000000002e-07 0 7.02000000000002e-07 0 7.02050000000002e-07 0 7.05000000000002e-07 0 7.05100000000002e-07 1 7.06000000000002e-07 1 7.06050000000002e-07 0 7.08000000000002e-07 0 7.08050000000002e-07 0 7.11000000000002e-07 0 7.11100000000002e-07 1 7.12000000000002e-07 1 7.12050000000002e-07 0 7.14000000000002e-07 0 7.14050000000002e-07 0 7.17000000000002e-07 0 7.17100000000002e-07 1 7.18000000000002e-07 1 7.18050000000002e-07 0 7.20000000000002e-07 0 7.20050000000002e-07 0 7.23000000000002e-07 0 7.23100000000002e-07 1 7.24000000000002e-07 1 7.24050000000002e-07 0 7.26000000000002e-07 0 7.26050000000002e-07 0 7.29000000000002e-07 0 7.29100000000002e-07 1 7.30000000000002e-07 1 7.30050000000002e-07 0 7.32000000000002e-07 0 7.32050000000002e-07 0 7.35000000000002e-07 0 7.35100000000002e-07 1 7.36000000000002e-07 1 7.36050000000002e-07 0 7.38000000000002e-07 0 7.38050000000002e-07 0 7.41000000000002e-07 0 7.41100000000002e-07 1 7.42000000000002e-07 1 7.42050000000002e-07 0 7.44000000000002e-07 0 7.44050000000002e-07 0 7.47000000000002e-07 0 7.47100000000002e-07 1 7.48000000000002e-07 1 7.48050000000002e-07 0 7.50000000000002e-07 0 7.50050000000002e-07 0 7.53000000000002e-07 0 7.53100000000002e-07 1 7.54000000000002e-07 1 7.54050000000002e-07 0 7.56000000000002e-07 0 7.56050000000002e-07 0 7.59000000000002e-07 0 7.59100000000002e-07 1 7.60000000000002e-07 1 7.60050000000002e-07 0 7.62000000000002e-07 0 7.62050000000002e-07 0 7.65000000000002e-07 0 7.65100000000002e-07 1 7.66000000000002e-07 1 7.66050000000002e-07 0 7.71500000000002e-07 0]
parameters wave_SAN = [0 0 4e-09 0 4.1e-09 1 5.5e-09 1 5.55e-09 0 6e-09 0 6.05e-09 0 1e-08 0 1.01e-08 1 1.15e-08 1 1.155e-08 0 1.2e-08 0 1.205e-08 0 1.6e-08 0 1.61e-08 1 1.75e-08 1 1.755e-08 0 1.8e-08 0 1.805e-08 0 2.2e-08 0 2.21e-08 1 2.35e-08 1 2.355e-08 0 2.4e-08 0 2.405e-08 0 2.8e-08 0 2.81e-08 1 2.95e-08 1 2.955e-08 0 3e-08 0 3.005e-08 0 3.4e-08 0 3.41e-08 1 3.55e-08 1 3.555e-08 0 3.6e-08 0 3.605e-08 0 4e-08 0 4.01e-08 1 4.15e-08 1 4.155e-08 0 4.2e-08 0 4.205e-08 0 4.6e-08 0 4.61e-08 1 4.75e-08 1 4.755e-08 0 4.8e-08 0 4.805e-08 0 5.2e-08 0 5.21e-08 1 5.35e-08 1 5.355e-08 0 5.4e-08 0 5.405e-08 0 5.8e-08 0 5.81e-08 1 5.95e-08 1 5.955e-08 0 6e-08 0 6.005e-08 0 6.4e-08 0 6.41e-08 1 6.55e-08 1 6.555e-08 0 6.6e-08 0 6.605e-08 0 7e-08 0 7.01e-08 1 7.15e-08 1 7.155e-08 0 7.2e-08 0 7.205e-08 0 7.6e-08 0 7.61e-08 1 7.75e-08 1 7.755e-08 0 7.8e-08 0 7.805e-08 0 8.2e-08 0 8.21e-08 1 8.35e-08 1 8.355e-08 0 8.4e-08 0 8.405e-08 0 8.8e-08 0 8.81e-08 1 8.95e-08 1 8.955e-08 0 9e-08 0 9.005e-08 0 9.4e-08 0 9.41e-08 1 9.55e-08 1 9.555e-08 0 9.6e-08 0 9.605e-08 0 1e-07 0 1.001e-07 1 1.015e-07 1 1.0155e-07 0 1.02e-07 0 1.0205e-07 0 1.06e-07 0 1.061e-07 1 1.075e-07 1 1.0755e-07 0 1.08e-07 0 1.0805e-07 0 1.12e-07 0 1.121e-07 1 1.135e-07 1 1.1355e-07 0 1.14e-07 0 1.1405e-07 0 1.18e-07 0 1.181e-07 1 1.195e-07 1 1.1955e-07 0 1.2e-07 0 1.2005e-07 0 1.24e-07 0 1.241e-07 1 1.255e-07 1 1.2555e-07 0 1.26e-07 0 1.2605e-07 0 1.3e-07 0 1.301e-07 1 1.315e-07 1 1.3155e-07 0 1.32e-07 0 1.3205e-07 0 1.36e-07 0 1.361e-07 1 1.375e-07 1 1.3755e-07 0 1.38e-07 0 1.3805e-07 0 1.42e-07 0 1.421e-07 1 1.435e-07 1 1.4355e-07 0 1.44e-07 0 1.4405e-07 0 1.48e-07 0 1.481e-07 1 1.495e-07 1 1.4955e-07 0 1.5e-07 0 1.5005e-07 0 1.54e-07 0 1.541e-07 1 1.555e-07 1 1.5555e-07 0 1.56e-07 0 1.5605e-07 0 1.6e-07 0 1.601e-07 1 1.615e-07 1 1.6155e-07 0 1.62e-07 0 1.6205e-07 0 1.66e-07 0 1.661e-07 1 1.675e-07 1 1.6755e-07 0 1.68e-07 0 1.6805e-07 0 1.72e-07 0 1.721e-07 1 1.735e-07 1 1.7355e-07 0 1.74e-07 0 1.7405e-07 0 1.78e-07 0 1.781e-07 1 1.795e-07 1 1.7955e-07 0 1.8e-07 0 1.8005e-07 0 1.84e-07 0 1.841e-07 1 1.855e-07 1 1.8555e-07 0 1.86e-07 0 1.8605e-07 0 1.9e-07 0 1.901e-07 1 1.915e-07 1 1.9155e-07 0 1.92e-07 0 1.9205e-07 0 1.96e-07 0 1.961e-07 1 1.975e-07 1 1.9755e-07 0 1.98e-07 0 1.9805e-07 0 2.02e-07 0 2.021e-07 1 2.035e-07 1 2.0355e-07 0 2.04e-07 0 2.0405e-07 0 2.08e-07 0 2.081e-07 1 2.095e-07 1 2.0955e-07 0 2.1e-07 0 2.1005e-07 0 2.14e-07 0 2.141e-07 1 2.155e-07 1 2.1555e-07 0 2.16e-07 0 2.1605e-07 0 2.2e-07 0 2.201e-07 1 2.215e-07 1 2.2155e-07 0 2.22e-07 0 2.2205e-07 0 2.26e-07 0 2.261e-07 1 2.275e-07 1 2.2755e-07 0 2.28000000000001e-07 0 2.28050000000001e-07 0 2.32000000000001e-07 0 2.32100000000001e-07 1 2.33500000000001e-07 1 2.33550000000001e-07 0 2.34000000000001e-07 0 2.34050000000001e-07 0 2.38000000000001e-07 0 2.38100000000001e-07 1 2.39500000000001e-07 1 2.39550000000001e-07 0 2.40000000000001e-07 0 2.40050000000001e-07 0 2.44e-07 0 2.441e-07 1 2.455e-07 1 2.45550000000001e-07 0 2.46e-07 0 2.4605e-07 0 2.5e-07 0 2.501e-07 1 2.515e-07 1 2.5155e-07 0 2.52e-07 0 2.5205e-07 0 2.56e-07 0 2.561e-07 1 2.575e-07 1 2.5755e-07 0 2.58e-07 0 2.5805e-07 0 2.62e-07 0 2.621e-07 1 2.635e-07 1 2.6355e-07 0 2.64e-07 0 2.6405e-07 0 2.68e-07 0 2.681e-07 1 2.695e-07 1 2.6955e-07 0 2.7e-07 0 2.7005e-07 0 2.74e-07 0 2.741e-07 1 2.755e-07 1 2.7555e-07 0 2.76e-07 0 2.7605e-07 0 2.8e-07 0 2.801e-07 1 2.815e-07 1 2.8155e-07 0 2.82e-07 0 2.8205e-07 0 2.86e-07 0 2.861e-07 1 2.875e-07 1 2.8755e-07 0 2.88e-07 0 2.8805e-07 0 2.92e-07 0 2.921e-07 1 2.935e-07 1 2.9355e-07 0 2.94e-07 0 2.9405e-07 0 2.98e-07 0 2.981e-07 1 2.995e-07 1 2.9955e-07 0 3e-07 0 3.0005e-07 0 3.04e-07 0 3.041e-07 1 3.055e-07 1 3.0555e-07 0 3.06e-07 0 3.0605e-07 0 3.1e-07 0 3.101e-07 1 3.115e-07 1 3.1155e-07 0 3.12e-07 0 3.1205e-07 0 3.16e-07 0 3.161e-07 1 3.175e-07 1 3.1755e-07 0 3.18e-07 0 3.1805e-07 0 3.22e-07 0 3.221e-07 1 3.235e-07 1 3.2355e-07 0 3.24e-07 0 3.2405e-07 0 3.28e-07 0 3.281e-07 1 3.295e-07 1 3.2955e-07 0 3.3e-07 0 3.3005e-07 0 3.34e-07 0 3.341e-07 1 3.355e-07 1 3.3555e-07 0 3.36e-07 0 3.3605e-07 0 3.4e-07 0 3.401e-07 1 3.415e-07 1 3.4155e-07 0 3.42e-07 0 3.4205e-07 0 3.46e-07 0 3.461e-07 1 3.475e-07 1 3.4755e-07 0 3.48e-07 0 3.4805e-07 0 3.52e-07 0 3.521e-07 1 3.535e-07 1 3.5355e-07 0 3.54e-07 0 3.5405e-07 0 3.58e-07 0 3.581e-07 1 3.595e-07 1 3.5955e-07 0 3.6e-07 0 3.6005e-07 0 3.64e-07 0 3.641e-07 1 3.655e-07 1 3.6555e-07 0 3.66e-07 0 3.6605e-07 0 3.7e-07 0 3.701e-07 1 3.715e-07 1 3.7155e-07 0 3.72e-07 0 3.7205e-07 0 3.76e-07 0 3.761e-07 1 3.775e-07 1 3.7755e-07 0 3.78e-07 0 3.7805e-07 0 3.82e-07 0 3.821e-07 1 3.835e-07 1 3.8355e-07 0 3.84e-07 0 3.8405e-07 0 3.88e-07 0 3.881e-07 1 3.895e-07 1 3.8955e-07 0 3.9e-07 0 3.9005e-07 0 3.94e-07 0 3.941e-07 1 3.955e-07 1 3.9555e-07 0 3.96e-07 0 3.9605e-07 0 4e-07 0 4.001e-07 1 4.015e-07 1 4.0155e-07 0 4.02e-07 0 4.0205e-07 0 4.06e-07 0 4.061e-07 1 4.075e-07 1 4.0755e-07 0 4.08e-07 0 4.0805e-07 0 4.12e-07 0 4.121e-07 1 4.135e-07 1 4.1355e-07 0 4.14e-07 0 4.1405e-07 0 4.18e-07 0 4.181e-07 1 4.195e-07 1 4.1955e-07 0 4.2e-07 0 4.2005e-07 0 4.24e-07 0 4.241e-07 1 4.255e-07 1 4.2555e-07 0 4.26e-07 0 4.2605e-07 0 4.3e-07 0 4.301e-07 1 4.315e-07 1 4.3155e-07 0 4.32e-07 0 4.3205e-07 0 4.36e-07 0 4.361e-07 1 4.375e-07 1 4.3755e-07 0 4.38e-07 0 4.3805e-07 0 4.42e-07 0 4.421e-07 1 4.435e-07 1 4.4355e-07 0 4.44e-07 0 4.4405e-07 0 4.48e-07 0 4.481e-07 1 4.495e-07 1 4.4955e-07 0 4.5e-07 0 4.5005e-07 0 4.54e-07 0 4.541e-07 1 4.555e-07 1 4.5555e-07 0 4.56e-07 0 4.5605e-07 0 4.6e-07 0 4.601e-07 1 4.615e-07 1 4.6155e-07 0 4.62e-07 0 4.6205e-07 0 4.66e-07 0 4.661e-07 1 4.675e-07 1 4.6755e-07 0 4.68e-07 0 4.6805e-07 0 4.72e-07 0 4.721e-07 1 4.735e-07 1 4.7355e-07 0 4.74e-07 0 4.7405e-07 0 4.77999999999999e-07 0 4.78099999999999e-07 1 4.79499999999999e-07 1 4.79549999999999e-07 0 4.8e-07 0 4.8005e-07 0 4.84e-07 0 4.841e-07 1 4.855e-07 1 4.8555e-07 0 4.86e-07 0 4.8605e-07 0 4.9e-07 0 4.901e-07 1 4.915e-07 1 4.9155e-07 0 4.92e-07 0 4.9205e-07 0 4.96e-07 0 4.961e-07 1 4.975e-07 1 4.9755e-07 0 4.98e-07 0 4.9805e-07 0 5.02e-07 0 5.021e-07 1 5.035e-07 1 5.0355e-07 0 5.04e-07 0 5.0405e-07 0 5.08e-07 0 5.081e-07 1 5.095e-07 1 5.0955e-07 0 5.1e-07 0 5.1005e-07 0 5.14e-07 0 5.141e-07 1 5.155e-07 1 5.1555e-07 0 5.16e-07 0 5.1605e-07 0 5.2e-07 0 5.201e-07 1 5.215e-07 1 5.2155e-07 0 5.22e-07 0 5.2205e-07 0 5.26e-07 0 5.261e-07 1 5.275e-07 1 5.2755e-07 0 5.28e-07 0 5.2805e-07 0 5.32e-07 0 5.321e-07 1 5.335e-07 1 5.3355e-07 0 5.34e-07 0 5.3405e-07 0 5.38e-07 0 5.381e-07 1 5.395e-07 1 5.3955e-07 0 5.4e-07 0 5.4005e-07 0 5.44e-07 0 5.441e-07 1 5.455e-07 1 5.4555e-07 0 5.46e-07 0 5.4605e-07 0 5.5e-07 0 5.501e-07 1 5.515e-07 1 5.5155e-07 0 5.52e-07 0 5.5205e-07 0 5.56e-07 0 5.561e-07 1 5.575e-07 1 5.5755e-07 0 5.58e-07 0 5.5805e-07 0 5.62e-07 0 5.621e-07 1 5.635e-07 1 5.6355e-07 0 5.64e-07 0 5.6405e-07 0 5.68e-07 0 5.681e-07 1 5.695e-07 1 5.6955e-07 0 5.7e-07 0 5.7005e-07 0 5.74e-07 0 5.741e-07 1 5.755e-07 1 5.7555e-07 0 5.76e-07 0 5.7605e-07 0 5.8e-07 0 5.801e-07 1 5.815e-07 1 5.8155e-07 0 5.82e-07 0 5.8205e-07 0 5.86e-07 0 5.861e-07 1 5.875e-07 1 5.8755e-07 0 5.88e-07 0 5.8805e-07 0 5.92e-07 0 5.921e-07 1 5.935e-07 1 5.9355e-07 0 5.94e-07 0 5.9405e-07 0 5.98e-07 0 5.981e-07 1 5.995e-07 1 5.9955e-07 0 6e-07 0 6.0005e-07 0 6.04e-07 0 6.041e-07 1 6.055e-07 1 6.0555e-07 0 6.06e-07 0 6.0605e-07 0 6.1e-07 0 6.101e-07 1 6.115e-07 1 6.1155e-07 0 6.12e-07 0 6.1205e-07 0 6.16e-07 0 6.161e-07 1 6.175e-07 1 6.1755e-07 0 6.18e-07 0 6.1805e-07 0 6.22e-07 0 6.221e-07 1 6.235e-07 1 6.2355e-07 0 6.24e-07 0 6.2405e-07 0 6.28e-07 0 6.281e-07 1 6.295e-07 1 6.2955e-07 0 6.3e-07 0 6.3005e-07 0 6.34e-07 0 6.341e-07 1 6.355e-07 1 6.3555e-07 0 6.36e-07 0 6.3605e-07 0 6.4e-07 0 6.401e-07 1 6.415e-07 1 6.4155e-07 0 6.42e-07 0 6.4205e-07 0 6.46e-07 0 6.461e-07 1 6.475e-07 1 6.4755e-07 0 6.48e-07 0 6.4805e-07 0 6.52e-07 0 6.521e-07 1 6.535e-07 1 6.5355e-07 0 6.54e-07 0 6.5405e-07 0 6.58e-07 0 6.581e-07 1 6.595e-07 1 6.5955e-07 0 6.6e-07 0 6.6005e-07 0 6.64e-07 0 6.641e-07 1 6.655e-07 1 6.6555e-07 0 6.66e-07 0 6.6605e-07 0 6.7e-07 0 6.701e-07 1 6.715e-07 1 6.7155e-07 0 6.72e-07 0 6.7205e-07 0 6.76e-07 0 6.761e-07 1 6.775e-07 1 6.7755e-07 0 6.78e-07 0 6.7805e-07 0 6.82e-07 0 6.821e-07 1 6.835e-07 1 6.8355e-07 0 6.84e-07 0 6.8405e-07 0 6.88e-07 0 6.881e-07 1 6.895e-07 1 6.8955e-07 0 6.9e-07 0 6.9005e-07 0 6.94e-07 0 6.941e-07 1 6.955e-07 1 6.9555e-07 0 6.96000000000001e-07 0 6.96050000000001e-07 0 7e-07 0 7.00100000000001e-07 1 7.01500000000001e-07 1 7.01550000000001e-07 0 7.02000000000001e-07 0 7.02050000000001e-07 0 7.06000000000001e-07 0 7.06100000000001e-07 1 7.07500000000001e-07 1 7.07550000000001e-07 0 7.08000000000001e-07 0 7.08050000000001e-07 0 7.12000000000001e-07 0 7.12100000000001e-07 1 7.13500000000001e-07 1 7.13550000000001e-07 0 7.14000000000001e-07 0 7.14050000000001e-07 0 7.18000000000001e-07 0 7.18100000000001e-07 1 7.19500000000001e-07 1 7.19550000000001e-07 0 7.20000000000001e-07 0 7.20050000000001e-07 0 7.24000000000001e-07 0 7.24100000000001e-07 1 7.25500000000001e-07 1 7.25550000000001e-07 0 7.26000000000001e-07 0 7.26050000000001e-07 0 7.30000000000001e-07 0 7.30100000000001e-07 1 7.31500000000001e-07 1 7.31550000000001e-07 0 7.32000000000001e-07 0 7.32050000000001e-07 0 7.36000000000001e-07 0 7.36100000000001e-07 1 7.37500000000001e-07 1 7.37550000000001e-07 0 7.38000000000001e-07 0 7.38050000000001e-07 0 7.42000000000001e-07 0 7.42100000000001e-07 1 7.43500000000001e-07 1 7.43550000000001e-07 0 7.44000000000001e-07 0 7.44050000000001e-07 0 7.48000000000001e-07 0 7.48100000000001e-07 1 7.49500000000001e-07 1 7.49550000000001e-07 0 7.50000000000001e-07 0 7.50050000000001e-07 0 7.54000000000001e-07 0 7.54100000000001e-07 1 7.55500000000001e-07 1 7.55550000000001e-07 0 7.56000000000001e-07 0 7.56050000000001e-07 0 7.60000000000001e-07 0 7.60100000000001e-07 1 7.61500000000001e-07 1 7.61550000000001e-07 0 7.62000000000001e-07 0 7.62050000000001e-07 0 7.66000000000001e-07 0 7.66100000000001e-07 1 7.67500000000001e-07 1 7.67550000000001e-07 0 7.73000000000001e-07 0]
parameters wave_SAP = [0 1 4e-09 1 4.05e-09 0 6e-09 0 6.1e-09 1 1e-08 1 1.005e-08 0 1.2e-08 0 1.21e-08 1 1.6e-08 1 1.605e-08 0 1.8e-08 0 1.81e-08 1 2.2e-08 1 2.205e-08 0 2.4e-08 0 2.41e-08 1 2.8e-08 1 2.805e-08 0 3e-08 0 3.01e-08 1 3.4e-08 1 3.405e-08 0 3.6e-08 0 3.61e-08 1 4e-08 1 4.005e-08 0 4.2e-08 0 4.21e-08 1 4.6e-08 1 4.605e-08 0 4.8e-08 0 4.81e-08 1 5.2e-08 1 5.205e-08 0 5.4e-08 0 5.41e-08 1 5.8e-08 1 5.805e-08 0 6e-08 0 6.01e-08 1 6.4e-08 1 6.405e-08 0 6.6e-08 0 6.61e-08 1 7e-08 1 7.005e-08 0 7.2e-08 0 7.21e-08 1 7.6e-08 1 7.605e-08 0 7.8e-08 0 7.81e-08 1 8.2e-08 1 8.205e-08 0 8.4e-08 0 8.41e-08 1 8.8e-08 1 8.805e-08 0 9e-08 0 9.01e-08 1 9.4e-08 1 9.405e-08 0 9.6e-08 0 9.61e-08 1 1e-07 1 1.0005e-07 0 1.02e-07 0 1.021e-07 1 1.06e-07 1 1.0605e-07 0 1.08e-07 0 1.081e-07 1 1.12e-07 1 1.1205e-07 0 1.14e-07 0 1.141e-07 1 1.18e-07 1 1.1805e-07 0 1.2e-07 0 1.201e-07 1 1.24e-07 1 1.2405e-07 0 1.26e-07 0 1.261e-07 1 1.3e-07 1 1.3005e-07 0 1.32e-07 0 1.321e-07 1 1.36e-07 1 1.3605e-07 0 1.38e-07 0 1.381e-07 1 1.42e-07 1 1.4205e-07 0 1.44e-07 0 1.441e-07 1 1.48e-07 1 1.4805e-07 0 1.5e-07 0 1.501e-07 1 1.54e-07 1 1.5405e-07 0 1.56e-07 0 1.561e-07 1 1.6e-07 1 1.6005e-07 0 1.62e-07 0 1.621e-07 1 1.66e-07 1 1.6605e-07 0 1.68e-07 0 1.681e-07 1 1.72e-07 1 1.7205e-07 0 1.74e-07 0 1.741e-07 1 1.78e-07 1 1.7805e-07 0 1.8e-07 0 1.801e-07 1 1.84e-07 1 1.8405e-07 0 1.86e-07 0 1.861e-07 1 1.9e-07 1 1.9005e-07 0 1.92e-07 0 1.921e-07 1 1.96e-07 1 1.9605e-07 0 1.98e-07 0 1.981e-07 1 2.02e-07 1 2.0205e-07 0 2.04e-07 0 2.041e-07 1 2.08e-07 1 2.0805e-07 0 2.1e-07 0 2.101e-07 1 2.14e-07 1 2.1405e-07 0 2.16e-07 0 2.161e-07 1 2.2e-07 1 2.2005e-07 0 2.22e-07 0 2.221e-07 1 2.26e-07 1 2.2605e-07 0 2.28000000000001e-07 0 2.28100000000001e-07 1 2.32000000000001e-07 1 2.32050000000001e-07 0 2.34000000000001e-07 0 2.34100000000001e-07 1 2.38000000000001e-07 1 2.38050000000001e-07 0 2.40000000000001e-07 0 2.40100000000001e-07 1 2.44e-07 1 2.4405e-07 0 2.46e-07 0 2.461e-07 1 2.5e-07 1 2.5005e-07 0 2.52e-07 0 2.521e-07 1 2.56e-07 1 2.5605e-07 0 2.58e-07 0 2.581e-07 1 2.62e-07 1 2.6205e-07 0 2.64e-07 0 2.641e-07 1 2.68e-07 1 2.6805e-07 0 2.7e-07 0 2.701e-07 1 2.74e-07 1 2.7405e-07 0 2.76e-07 0 2.761e-07 1 2.8e-07 1 2.8005e-07 0 2.82e-07 0 2.821e-07 1 2.86e-07 1 2.8605e-07 0 2.88e-07 0 2.881e-07 1 2.92e-07 1 2.9205e-07 0 2.94e-07 0 2.941e-07 1 2.98e-07 1 2.9805e-07 0 3e-07 0 3.001e-07 1 3.04e-07 1 3.0405e-07 0 3.06e-07 0 3.061e-07 1 3.1e-07 1 3.1005e-07 0 3.12e-07 0 3.121e-07 1 3.16e-07 1 3.1605e-07 0 3.18e-07 0 3.181e-07 1 3.22e-07 1 3.2205e-07 0 3.24e-07 0 3.241e-07 1 3.28e-07 1 3.2805e-07 0 3.3e-07 0 3.301e-07 1 3.34e-07 1 3.3405e-07 0 3.36e-07 0 3.361e-07 1 3.4e-07 1 3.4005e-07 0 3.42e-07 0 3.421e-07 1 3.46e-07 1 3.4605e-07 0 3.48e-07 0 3.481e-07 1 3.52e-07 1 3.5205e-07 0 3.54e-07 0 3.541e-07 1 3.58e-07 1 3.5805e-07 0 3.6e-07 0 3.601e-07 1 3.64e-07 1 3.6405e-07 0 3.66e-07 0 3.661e-07 1 3.7e-07 1 3.7005e-07 0 3.72e-07 0 3.721e-07 1 3.76e-07 1 3.7605e-07 0 3.78e-07 0 3.781e-07 1 3.82e-07 1 3.8205e-07 0 3.84e-07 0 3.841e-07 1 3.88e-07 1 3.8805e-07 0 3.9e-07 0 3.901e-07 1 3.94e-07 1 3.9405e-07 0 3.96e-07 0 3.961e-07 1 4e-07 1 4.0005e-07 0 4.02e-07 0 4.021e-07 1 4.06e-07 1 4.0605e-07 0 4.08e-07 0 4.081e-07 1 4.12e-07 1 4.1205e-07 0 4.14e-07 0 4.141e-07 1 4.18e-07 1 4.1805e-07 0 4.2e-07 0 4.201e-07 1 4.24e-07 1 4.2405e-07 0 4.26e-07 0 4.261e-07 1 4.3e-07 1 4.3005e-07 0 4.32e-07 0 4.321e-07 1 4.36e-07 1 4.3605e-07 0 4.38e-07 0 4.381e-07 1 4.42e-07 1 4.4205e-07 0 4.44e-07 0 4.441e-07 1 4.48e-07 1 4.4805e-07 0 4.5e-07 0 4.501e-07 1 4.54e-07 1 4.5405e-07 0 4.56e-07 0 4.561e-07 1 4.6e-07 1 4.6005e-07 0 4.62e-07 0 4.621e-07 1 4.66e-07 1 4.6605e-07 0 4.68e-07 0 4.681e-07 1 4.72e-07 1 4.7205e-07 0 4.74e-07 0 4.741e-07 1 4.77999999999999e-07 1 4.78049999999999e-07 0 4.8e-07 0 4.801e-07 1 4.84e-07 1 4.8405e-07 0 4.86e-07 0 4.861e-07 1 4.9e-07 1 4.9005e-07 0 4.92e-07 0 4.921e-07 1 4.96e-07 1 4.9605e-07 0 4.98e-07 0 4.981e-07 1 5.02e-07 1 5.0205e-07 0 5.04e-07 0 5.041e-07 1 5.08e-07 1 5.0805e-07 0 5.1e-07 0 5.101e-07 1 5.14e-07 1 5.1405e-07 0 5.16e-07 0 5.161e-07 1 5.2e-07 1 5.2005e-07 0 5.22e-07 0 5.221e-07 1 5.26e-07 1 5.2605e-07 0 5.28e-07 0 5.281e-07 1 5.32e-07 1 5.3205e-07 0 5.34e-07 0 5.341e-07 1 5.38e-07 1 5.3805e-07 0 5.4e-07 0 5.401e-07 1 5.44e-07 1 5.4405e-07 0 5.46e-07 0 5.461e-07 1 5.5e-07 1 5.5005e-07 0 5.52e-07 0 5.521e-07 1 5.56e-07 1 5.5605e-07 0 5.58e-07 0 5.581e-07 1 5.62e-07 1 5.6205e-07 0 5.64e-07 0 5.641e-07 1 5.68e-07 1 5.6805e-07 0 5.7e-07 0 5.701e-07 1 5.74e-07 1 5.7405e-07 0 5.76e-07 0 5.761e-07 1 5.8e-07 1 5.8005e-07 0 5.82e-07 0 5.821e-07 1 5.86e-07 1 5.8605e-07 0 5.88e-07 0 5.881e-07 1 5.92e-07 1 5.9205e-07 0 5.94e-07 0 5.941e-07 1 5.98e-07 1 5.9805e-07 0 6e-07 0 6.001e-07 1 6.04e-07 1 6.0405e-07 0 6.06e-07 0 6.061e-07 1 6.1e-07 1 6.1005e-07 0 6.12e-07 0 6.121e-07 1 6.16e-07 1 6.1605e-07 0 6.18e-07 0 6.181e-07 1 6.22e-07 1 6.2205e-07 0 6.24e-07 0 6.241e-07 1 6.28e-07 1 6.2805e-07 0 6.3e-07 0 6.301e-07 1 6.34e-07 1 6.3405e-07 0 6.36e-07 0 6.361e-07 1 6.4e-07 1 6.4005e-07 0 6.42e-07 0 6.421e-07 1 6.46e-07 1 6.4605e-07 0 6.48e-07 0 6.481e-07 1 6.52e-07 1 6.5205e-07 0 6.54e-07 0 6.541e-07 1 6.58e-07 1 6.5805e-07 0 6.6e-07 0 6.601e-07 1 6.64e-07 1 6.6405e-07 0 6.66e-07 0 6.661e-07 1 6.7e-07 1 6.7005e-07 0 6.72e-07 0 6.721e-07 1 6.76e-07 1 6.7605e-07 0 6.78e-07 0 6.781e-07 1 6.82e-07 1 6.8205e-07 0 6.84e-07 0 6.841e-07 1 6.88e-07 1 6.8805e-07 0 6.9e-07 0 6.901e-07 1 6.94e-07 1 6.9405e-07 0 6.96000000000001e-07 0 6.96100000000001e-07 1 7e-07 1 7.00050000000001e-07 0 7.02000000000001e-07 0 7.02100000000001e-07 1 7.06000000000001e-07 1 7.06050000000001e-07 0 7.08000000000001e-07 0 7.08100000000001e-07 1 7.12000000000001e-07 1 7.12050000000001e-07 0 7.14000000000001e-07 0 7.14100000000001e-07 1 7.18000000000001e-07 1 7.18050000000001e-07 0 7.20000000000001e-07 0 7.20100000000001e-07 1 7.24000000000001e-07 1 7.24050000000001e-07 0 7.26000000000001e-07 0 7.26100000000001e-07 1 7.30000000000001e-07 1 7.30050000000001e-07 0 7.32000000000001e-07 0 7.32100000000001e-07 1 7.36000000000001e-07 1 7.36050000000001e-07 0 7.38000000000001e-07 0 7.38100000000001e-07 1 7.42000000000001e-07 1 7.42050000000001e-07 0 7.44000000000001e-07 0 7.44100000000001e-07 1 7.48000000000001e-07 1 7.48050000000001e-07 0 7.50000000000001e-07 0 7.50100000000001e-07 1 7.54000000000001e-07 1 7.54050000000001e-07 0 7.56000000000001e-07 0 7.56100000000001e-07 1 7.60000000000001e-07 1 7.60050000000001e-07 0 7.62000000000001e-07 0 7.62100000000001e-07 1 7.66000000000001e-07 1 7.66050000000001e-07 0 7.67500000000001e-07 0 7.67600000000001e-07 1 7.73000000000001e-07 1]
