simulator lang=spectre

parameters vdd = 1

parameters PWmin = 100n                         //MinimalTransistorWidth
parameters PLmin = 45n                          //MinimalTransistorLenght
parameters WChargeBL = 3e-07         //BitLineChargerWidth(perBL)
parameters LChargeBL = 1.95e-07
parameters WDischargeBL = 1e-07   //BitLineDischargerWidth(perBL)
parameters WDischargeSL = 5e-07   //SourceLineDischargerWidth(perBL)
parameters Cpar = 0.18e-15                      //ParasiticCapacitor(perCell)
parameters PWn = 1e-07                     //DifferentialNpairWidth(perSA)
parameters PWp = 1e-07                     //DifferentialPpairWidth(perSA)
parameters PWpenable = 1e-07         //SenseAmpEnablePWidth(perSA)
parameters PWnenable = 1e-07         //SenseAmpEnableNWidth(perSA)
parameters PWmuxLB = 2e-07                //PassgateWidth(perMuxLB)
parameters PWmuxGB = 2e-07                //PassgateWidth(perMuxGB)

parameters numberofruns = 1
parameters enableMismatch = 0   //Mismatch
parameters simlength = 1.8e-08

parameters RMEMHigh = 32500;
parameters RMEMLow = 7500;

parameters Rcell_0_0_0_0 = RMEMHigh
parameters Rcell_0_0_0_1 = RMEMLow
parameters Rcell_0_0_0_2 = RMEMHigh
parameters Rcell_0_0_0_3 = RMEMLow
parameters Rcell_0_0_0_4 = RMEMHigh
parameters Rcell_0_0_0_5 = RMEMLow
parameters Rcell_0_0_0_6 = RMEMLow
parameters Rcell_0_0_0_7 = RMEMHigh
parameters Rcell_0_0_0_8 = RMEMHigh
parameters Rcell_0_0_0_9 = RMEMLow
parameters Rcell_0_0_0_10 = RMEMHigh
parameters Rcell_0_0_0_11 = RMEMHigh
parameters Rcell_0_0_0_12 = RMEMLow
parameters Rcell_0_0_0_13 = RMEMHigh
parameters Rcell_0_0_0_14 = RMEMHigh
parameters Rcell_0_0_0_15 = RMEMLow
parameters Rcell_0_0_1_0 = RMEMLow
parameters Rcell_0_0_1_1 = RMEMHigh
parameters Rcell_0_0_1_2 = RMEMHigh
parameters Rcell_0_0_1_3 = RMEMLow
parameters Rcell_0_0_1_4 = RMEMHigh
parameters Rcell_0_0_1_5 = RMEMLow
parameters Rcell_0_0_1_6 = RMEMLow
parameters Rcell_0_0_1_7 = RMEMLow
parameters Rcell_0_0_1_8 = RMEMHigh
parameters Rcell_0_0_1_9 = RMEMHigh
parameters Rcell_0_0_1_10 = RMEMLow
parameters Rcell_0_0_1_11 = RMEMLow
parameters Rcell_0_0_1_12 = RMEMHigh
parameters Rcell_0_0_1_13 = RMEMHigh
parameters Rcell_0_0_1_14 = RMEMHigh
parameters Rcell_0_0_1_15 = RMEMHigh
parameters Rcell_0_0_2_0 = RMEMLow
parameters Rcell_0_0_2_1 = RMEMHigh
parameters Rcell_0_0_2_2 = RMEMHigh
parameters Rcell_0_0_2_3 = RMEMHigh
parameters Rcell_0_0_2_4 = RMEMHigh
parameters Rcell_0_0_2_5 = RMEMLow
parameters Rcell_0_0_2_6 = RMEMLow
parameters Rcell_0_0_2_7 = RMEMLow
parameters Rcell_0_0_2_8 = RMEMLow
parameters Rcell_0_0_2_9 = RMEMHigh
parameters Rcell_0_0_2_10 = RMEMHigh
parameters Rcell_0_0_2_11 = RMEMLow
parameters Rcell_0_0_2_12 = RMEMLow
parameters Rcell_0_0_2_13 = RMEMLow
parameters Rcell_0_0_2_14 = RMEMLow
parameters Rcell_0_0_2_15 = RMEMHigh
parameters Rcell_0_0_3_0 = RMEMHigh
parameters Rcell_0_0_3_1 = RMEMHigh
parameters Rcell_0_0_3_2 = RMEMLow
parameters Rcell_0_0_3_3 = RMEMLow
parameters Rcell_0_0_3_4 = RMEMLow
parameters Rcell_0_0_3_5 = RMEMHigh
parameters Rcell_0_0_3_6 = RMEMHigh
parameters Rcell_0_0_3_7 = RMEMHigh
parameters Rcell_0_0_3_8 = RMEMHigh
parameters Rcell_0_0_3_9 = RMEMHigh
parameters Rcell_0_0_3_10 = RMEMHigh
parameters Rcell_0_0_3_11 = RMEMHigh
parameters Rcell_0_0_3_12 = RMEMHigh
parameters Rcell_0_0_3_13 = RMEMHigh
parameters Rcell_0_0_3_14 = RMEMHigh
parameters Rcell_0_0_3_15 = RMEMLow
parameters Rcell_0_0_4_0 = RMEMHigh
parameters Rcell_0_0_4_1 = RMEMHigh
parameters Rcell_0_0_4_2 = RMEMHigh
parameters Rcell_0_0_4_3 = RMEMLow
parameters Rcell_0_0_4_4 = RMEMHigh
parameters Rcell_0_0_4_5 = RMEMLow
parameters Rcell_0_0_4_6 = RMEMLow
parameters Rcell_0_0_4_7 = RMEMLow
parameters Rcell_0_0_4_8 = RMEMHigh
parameters Rcell_0_0_4_9 = RMEMLow
parameters Rcell_0_0_4_10 = RMEMHigh
parameters Rcell_0_0_4_11 = RMEMLow
parameters Rcell_0_0_4_12 = RMEMLow
parameters Rcell_0_0_4_13 = RMEMLow
parameters Rcell_0_0_4_14 = RMEMHigh
parameters Rcell_0_0_4_15 = RMEMLow
parameters Rcell_0_0_5_0 = RMEMLow
parameters Rcell_0_0_5_1 = RMEMHigh
parameters Rcell_0_0_5_2 = RMEMLow
parameters Rcell_0_0_5_3 = RMEMHigh
parameters Rcell_0_0_5_4 = RMEMHigh
parameters Rcell_0_0_5_5 = RMEMLow
parameters Rcell_0_0_5_6 = RMEMLow
parameters Rcell_0_0_5_7 = RMEMLow
parameters Rcell_0_0_5_8 = RMEMHigh
parameters Rcell_0_0_5_9 = RMEMLow
parameters Rcell_0_0_5_10 = RMEMHigh
parameters Rcell_0_0_5_11 = RMEMHigh
parameters Rcell_0_0_5_12 = RMEMLow
parameters Rcell_0_0_5_13 = RMEMLow
parameters Rcell_0_0_5_14 = RMEMLow
parameters Rcell_0_0_5_15 = RMEMLow
parameters Rcell_0_0_6_0 = RMEMLow
parameters Rcell_0_0_6_1 = RMEMLow
parameters Rcell_0_0_6_2 = RMEMLow
parameters Rcell_0_0_6_3 = RMEMHigh
parameters Rcell_0_0_6_4 = RMEMHigh
parameters Rcell_0_0_6_5 = RMEMHigh
parameters Rcell_0_0_6_6 = RMEMHigh
parameters Rcell_0_0_6_7 = RMEMHigh
parameters Rcell_0_0_6_8 = RMEMHigh
parameters Rcell_0_0_6_9 = RMEMLow
parameters Rcell_0_0_6_10 = RMEMHigh
parameters Rcell_0_0_6_11 = RMEMLow
parameters Rcell_0_0_6_12 = RMEMLow
parameters Rcell_0_0_6_13 = RMEMLow
parameters Rcell_0_0_6_14 = RMEMHigh
parameters Rcell_0_0_6_15 = RMEMLow
parameters Rcell_0_0_7_0 = RMEMLow
parameters Rcell_0_0_7_1 = RMEMLow
parameters Rcell_0_0_7_2 = RMEMHigh
parameters Rcell_0_0_7_3 = RMEMHigh
parameters Rcell_0_0_7_4 = RMEMLow
parameters Rcell_0_0_7_5 = RMEMLow
parameters Rcell_0_0_7_6 = RMEMHigh
parameters Rcell_0_0_7_7 = RMEMHigh
parameters Rcell_0_0_7_8 = RMEMLow
parameters Rcell_0_0_7_9 = RMEMLow
parameters Rcell_0_0_7_10 = RMEMLow
parameters Rcell_0_0_7_11 = RMEMHigh
parameters Rcell_0_0_7_12 = RMEMHigh
parameters Rcell_0_0_7_13 = RMEMLow
parameters Rcell_0_0_7_14 = RMEMLow
parameters Rcell_0_0_7_15 = RMEMLow
parameters Rcell_0_0_8_0 = RMEMLow
parameters Rcell_0_0_8_1 = RMEMHigh
parameters Rcell_0_0_8_2 = RMEMLow
parameters Rcell_0_0_8_3 = RMEMLow
parameters Rcell_0_0_8_4 = RMEMLow
parameters Rcell_0_0_8_5 = RMEMHigh
parameters Rcell_0_0_8_6 = RMEMHigh
parameters Rcell_0_0_8_7 = RMEMLow
parameters Rcell_0_0_8_8 = RMEMHigh
parameters Rcell_0_0_8_9 = RMEMLow
parameters Rcell_0_0_8_10 = RMEMHigh
parameters Rcell_0_0_8_11 = RMEMLow
parameters Rcell_0_0_8_12 = RMEMHigh
parameters Rcell_0_0_8_13 = RMEMLow
parameters Rcell_0_0_8_14 = RMEMLow
parameters Rcell_0_0_8_15 = RMEMLow
parameters Rcell_0_0_9_0 = RMEMHigh
parameters Rcell_0_0_9_1 = RMEMHigh
parameters Rcell_0_0_9_2 = RMEMHigh
parameters Rcell_0_0_9_3 = RMEMLow
parameters Rcell_0_0_9_4 = RMEMLow
parameters Rcell_0_0_9_5 = RMEMHigh
parameters Rcell_0_0_9_6 = RMEMLow
parameters Rcell_0_0_9_7 = RMEMHigh
parameters Rcell_0_0_9_8 = RMEMHigh
parameters Rcell_0_0_9_9 = RMEMHigh
parameters Rcell_0_0_9_10 = RMEMLow
parameters Rcell_0_0_9_11 = RMEMHigh
parameters Rcell_0_0_9_12 = RMEMLow
parameters Rcell_0_0_9_13 = RMEMHigh
parameters Rcell_0_0_9_14 = RMEMHigh
parameters Rcell_0_0_9_15 = RMEMHigh
parameters Rcell_0_0_10_0 = RMEMLow
parameters Rcell_0_0_10_1 = RMEMLow
parameters Rcell_0_0_10_2 = RMEMHigh
parameters Rcell_0_0_10_3 = RMEMLow
parameters Rcell_0_0_10_4 = RMEMLow
parameters Rcell_0_0_10_5 = RMEMLow
parameters Rcell_0_0_10_6 = RMEMLow
parameters Rcell_0_0_10_7 = RMEMLow
parameters Rcell_0_0_10_8 = RMEMHigh
parameters Rcell_0_0_10_9 = RMEMLow
parameters Rcell_0_0_10_10 = RMEMLow
parameters Rcell_0_0_10_11 = RMEMLow
parameters Rcell_0_0_10_12 = RMEMLow
parameters Rcell_0_0_10_13 = RMEMLow
parameters Rcell_0_0_10_14 = RMEMLow
parameters Rcell_0_0_10_15 = RMEMLow
parameters Rcell_0_0_11_0 = RMEMLow
parameters Rcell_0_0_11_1 = RMEMLow
parameters Rcell_0_0_11_2 = RMEMHigh
parameters Rcell_0_0_11_3 = RMEMLow
parameters Rcell_0_0_11_4 = RMEMLow
parameters Rcell_0_0_11_5 = RMEMHigh
parameters Rcell_0_0_11_6 = RMEMLow
parameters Rcell_0_0_11_7 = RMEMHigh
parameters Rcell_0_0_11_8 = RMEMLow
parameters Rcell_0_0_11_9 = RMEMHigh
parameters Rcell_0_0_11_10 = RMEMHigh
parameters Rcell_0_0_11_11 = RMEMHigh
parameters Rcell_0_0_11_12 = RMEMHigh
parameters Rcell_0_0_11_13 = RMEMHigh
parameters Rcell_0_0_11_14 = RMEMLow
parameters Rcell_0_0_11_15 = RMEMHigh
parameters Rcell_0_0_12_0 = RMEMLow
parameters Rcell_0_0_12_1 = RMEMLow
parameters Rcell_0_0_12_2 = RMEMHigh
parameters Rcell_0_0_12_3 = RMEMHigh
parameters Rcell_0_0_12_4 = RMEMLow
parameters Rcell_0_0_12_5 = RMEMHigh
parameters Rcell_0_0_12_6 = RMEMHigh
parameters Rcell_0_0_12_7 = RMEMLow
parameters Rcell_0_0_12_8 = RMEMHigh
parameters Rcell_0_0_12_9 = RMEMHigh
parameters Rcell_0_0_12_10 = RMEMLow
parameters Rcell_0_0_12_11 = RMEMHigh
parameters Rcell_0_0_12_12 = RMEMLow
parameters Rcell_0_0_12_13 = RMEMHigh
parameters Rcell_0_0_12_14 = RMEMHigh
parameters Rcell_0_0_12_15 = RMEMLow
parameters Rcell_0_0_13_0 = RMEMHigh
parameters Rcell_0_0_13_1 = RMEMLow
parameters Rcell_0_0_13_2 = RMEMLow
parameters Rcell_0_0_13_3 = RMEMHigh
parameters Rcell_0_0_13_4 = RMEMHigh
parameters Rcell_0_0_13_5 = RMEMHigh
parameters Rcell_0_0_13_6 = RMEMLow
parameters Rcell_0_0_13_7 = RMEMHigh
parameters Rcell_0_0_13_8 = RMEMHigh
parameters Rcell_0_0_13_9 = RMEMHigh
parameters Rcell_0_0_13_10 = RMEMHigh
parameters Rcell_0_0_13_11 = RMEMHigh
parameters Rcell_0_0_13_12 = RMEMLow
parameters Rcell_0_0_13_13 = RMEMHigh
parameters Rcell_0_0_13_14 = RMEMLow
parameters Rcell_0_0_13_15 = RMEMHigh
parameters Rcell_0_0_14_0 = RMEMLow
parameters Rcell_0_0_14_1 = RMEMHigh
parameters Rcell_0_0_14_2 = RMEMLow
parameters Rcell_0_0_14_3 = RMEMHigh
parameters Rcell_0_0_14_4 = RMEMHigh
parameters Rcell_0_0_14_5 = RMEMLow
parameters Rcell_0_0_14_6 = RMEMHigh
parameters Rcell_0_0_14_7 = RMEMLow
parameters Rcell_0_0_14_8 = RMEMHigh
parameters Rcell_0_0_14_9 = RMEMHigh
parameters Rcell_0_0_14_10 = RMEMHigh
parameters Rcell_0_0_14_11 = RMEMLow
parameters Rcell_0_0_14_12 = RMEMLow
parameters Rcell_0_0_14_13 = RMEMHigh
parameters Rcell_0_0_14_14 = RMEMLow
parameters Rcell_0_0_14_15 = RMEMLow
parameters Rcell_0_0_15_0 = RMEMLow
parameters Rcell_0_0_15_1 = RMEMLow
parameters Rcell_0_0_15_2 = RMEMHigh
parameters Rcell_0_0_15_3 = RMEMLow
parameters Rcell_0_0_15_4 = RMEMHigh
parameters Rcell_0_0_15_5 = RMEMLow
parameters Rcell_0_0_15_6 = RMEMHigh
parameters Rcell_0_0_15_7 = RMEMHigh
parameters Rcell_0_0_15_8 = RMEMLow
parameters Rcell_0_0_15_9 = RMEMLow
parameters Rcell_0_0_15_10 = RMEMHigh
parameters Rcell_0_0_15_11 = RMEMLow
parameters Rcell_0_0_15_12 = RMEMLow
parameters Rcell_0_0_15_13 = RMEMHigh
parameters Rcell_0_0_15_14 = RMEMHigh
parameters Rcell_0_0_15_15 = RMEMHigh
parameters Rcell_0_1_0_0 = RMEMLow
parameters Rcell_0_1_0_1 = RMEMHigh
parameters Rcell_0_1_0_2 = RMEMLow
parameters Rcell_0_1_0_3 = RMEMLow
parameters Rcell_0_1_0_4 = RMEMLow
parameters Rcell_0_1_0_5 = RMEMLow
parameters Rcell_0_1_0_6 = RMEMHigh
parameters Rcell_0_1_0_7 = RMEMLow
parameters Rcell_0_1_0_8 = RMEMLow
parameters Rcell_0_1_0_9 = RMEMLow
parameters Rcell_0_1_0_10 = RMEMLow
parameters Rcell_0_1_0_11 = RMEMLow
parameters Rcell_0_1_0_12 = RMEMHigh
parameters Rcell_0_1_0_13 = RMEMHigh
parameters Rcell_0_1_0_14 = RMEMLow
parameters Rcell_0_1_0_15 = RMEMHigh
parameters Rcell_0_1_1_0 = RMEMLow
parameters Rcell_0_1_1_1 = RMEMHigh
parameters Rcell_0_1_1_2 = RMEMHigh
parameters Rcell_0_1_1_3 = RMEMHigh
parameters Rcell_0_1_1_4 = RMEMHigh
parameters Rcell_0_1_1_5 = RMEMHigh
parameters Rcell_0_1_1_6 = RMEMLow
parameters Rcell_0_1_1_7 = RMEMHigh
parameters Rcell_0_1_1_8 = RMEMLow
parameters Rcell_0_1_1_9 = RMEMLow
parameters Rcell_0_1_1_10 = RMEMHigh
parameters Rcell_0_1_1_11 = RMEMLow
parameters Rcell_0_1_1_12 = RMEMHigh
parameters Rcell_0_1_1_13 = RMEMLow
parameters Rcell_0_1_1_14 = RMEMLow
parameters Rcell_0_1_1_15 = RMEMHigh
parameters Rcell_0_1_2_0 = RMEMHigh
parameters Rcell_0_1_2_1 = RMEMLow
parameters Rcell_0_1_2_2 = RMEMLow
parameters Rcell_0_1_2_3 = RMEMHigh
parameters Rcell_0_1_2_4 = RMEMHigh
parameters Rcell_0_1_2_5 = RMEMHigh
parameters Rcell_0_1_2_6 = RMEMLow
parameters Rcell_0_1_2_7 = RMEMHigh
parameters Rcell_0_1_2_8 = RMEMHigh
parameters Rcell_0_1_2_9 = RMEMHigh
parameters Rcell_0_1_2_10 = RMEMLow
parameters Rcell_0_1_2_11 = RMEMHigh
parameters Rcell_0_1_2_12 = RMEMHigh
parameters Rcell_0_1_2_13 = RMEMHigh
parameters Rcell_0_1_2_14 = RMEMHigh
parameters Rcell_0_1_2_15 = RMEMHigh
parameters Rcell_0_1_3_0 = RMEMLow
parameters Rcell_0_1_3_1 = RMEMLow
parameters Rcell_0_1_3_2 = RMEMLow
parameters Rcell_0_1_3_3 = RMEMHigh
parameters Rcell_0_1_3_4 = RMEMLow
parameters Rcell_0_1_3_5 = RMEMHigh
parameters Rcell_0_1_3_6 = RMEMLow
parameters Rcell_0_1_3_7 = RMEMLow
parameters Rcell_0_1_3_8 = RMEMHigh
parameters Rcell_0_1_3_9 = RMEMLow
parameters Rcell_0_1_3_10 = RMEMLow
parameters Rcell_0_1_3_11 = RMEMHigh
parameters Rcell_0_1_3_12 = RMEMHigh
parameters Rcell_0_1_3_13 = RMEMLow
parameters Rcell_0_1_3_14 = RMEMLow
parameters Rcell_0_1_3_15 = RMEMLow
parameters Rcell_0_1_4_0 = RMEMLow
parameters Rcell_0_1_4_1 = RMEMHigh
parameters Rcell_0_1_4_2 = RMEMLow
parameters Rcell_0_1_4_3 = RMEMLow
parameters Rcell_0_1_4_4 = RMEMLow
parameters Rcell_0_1_4_5 = RMEMLow
parameters Rcell_0_1_4_6 = RMEMLow
parameters Rcell_0_1_4_7 = RMEMHigh
parameters Rcell_0_1_4_8 = RMEMLow
parameters Rcell_0_1_4_9 = RMEMLow
parameters Rcell_0_1_4_10 = RMEMHigh
parameters Rcell_0_1_4_11 = RMEMHigh
parameters Rcell_0_1_4_12 = RMEMLow
parameters Rcell_0_1_4_13 = RMEMLow
parameters Rcell_0_1_4_14 = RMEMLow
parameters Rcell_0_1_4_15 = RMEMLow
parameters Rcell_0_1_5_0 = RMEMLow
parameters Rcell_0_1_5_1 = RMEMLow
parameters Rcell_0_1_5_2 = RMEMLow
parameters Rcell_0_1_5_3 = RMEMLow
parameters Rcell_0_1_5_4 = RMEMLow
parameters Rcell_0_1_5_5 = RMEMHigh
parameters Rcell_0_1_5_6 = RMEMHigh
parameters Rcell_0_1_5_7 = RMEMHigh
parameters Rcell_0_1_5_8 = RMEMHigh
parameters Rcell_0_1_5_9 = RMEMHigh
parameters Rcell_0_1_5_10 = RMEMHigh
parameters Rcell_0_1_5_11 = RMEMHigh
parameters Rcell_0_1_5_12 = RMEMHigh
parameters Rcell_0_1_5_13 = RMEMHigh
parameters Rcell_0_1_5_14 = RMEMLow
parameters Rcell_0_1_5_15 = RMEMHigh
parameters Rcell_0_1_6_0 = RMEMHigh
parameters Rcell_0_1_6_1 = RMEMLow
parameters Rcell_0_1_6_2 = RMEMLow
parameters Rcell_0_1_6_3 = RMEMHigh
parameters Rcell_0_1_6_4 = RMEMLow
parameters Rcell_0_1_6_5 = RMEMHigh
parameters Rcell_0_1_6_6 = RMEMLow
parameters Rcell_0_1_6_7 = RMEMHigh
parameters Rcell_0_1_6_8 = RMEMHigh
parameters Rcell_0_1_6_9 = RMEMHigh
parameters Rcell_0_1_6_10 = RMEMLow
parameters Rcell_0_1_6_11 = RMEMLow
parameters Rcell_0_1_6_12 = RMEMLow
parameters Rcell_0_1_6_13 = RMEMHigh
parameters Rcell_0_1_6_14 = RMEMLow
parameters Rcell_0_1_6_15 = RMEMLow
parameters Rcell_0_1_7_0 = RMEMHigh
parameters Rcell_0_1_7_1 = RMEMLow
parameters Rcell_0_1_7_2 = RMEMLow
parameters Rcell_0_1_7_3 = RMEMHigh
parameters Rcell_0_1_7_4 = RMEMLow
parameters Rcell_0_1_7_5 = RMEMLow
parameters Rcell_0_1_7_6 = RMEMHigh
parameters Rcell_0_1_7_7 = RMEMHigh
parameters Rcell_0_1_7_8 = RMEMLow
parameters Rcell_0_1_7_9 = RMEMHigh
parameters Rcell_0_1_7_10 = RMEMHigh
parameters Rcell_0_1_7_11 = RMEMLow
parameters Rcell_0_1_7_12 = RMEMHigh
parameters Rcell_0_1_7_13 = RMEMHigh
parameters Rcell_0_1_7_14 = RMEMLow
parameters Rcell_0_1_7_15 = RMEMLow
parameters Rcell_0_1_8_0 = RMEMHigh
parameters Rcell_0_1_8_1 = RMEMLow
parameters Rcell_0_1_8_2 = RMEMHigh
parameters Rcell_0_1_8_3 = RMEMHigh
parameters Rcell_0_1_8_4 = RMEMHigh
parameters Rcell_0_1_8_5 = RMEMLow
parameters Rcell_0_1_8_6 = RMEMHigh
parameters Rcell_0_1_8_7 = RMEMLow
parameters Rcell_0_1_8_8 = RMEMHigh
parameters Rcell_0_1_8_9 = RMEMLow
parameters Rcell_0_1_8_10 = RMEMLow
parameters Rcell_0_1_8_11 = RMEMHigh
parameters Rcell_0_1_8_12 = RMEMLow
parameters Rcell_0_1_8_13 = RMEMLow
parameters Rcell_0_1_8_14 = RMEMLow
parameters Rcell_0_1_8_15 = RMEMLow
parameters Rcell_0_1_9_0 = RMEMLow
parameters Rcell_0_1_9_1 = RMEMHigh
parameters Rcell_0_1_9_2 = RMEMLow
parameters Rcell_0_1_9_3 = RMEMHigh
parameters Rcell_0_1_9_4 = RMEMHigh
parameters Rcell_0_1_9_5 = RMEMLow
parameters Rcell_0_1_9_6 = RMEMHigh
parameters Rcell_0_1_9_7 = RMEMLow
parameters Rcell_0_1_9_8 = RMEMHigh
parameters Rcell_0_1_9_9 = RMEMLow
parameters Rcell_0_1_9_10 = RMEMLow
parameters Rcell_0_1_9_11 = RMEMHigh
parameters Rcell_0_1_9_12 = RMEMHigh
parameters Rcell_0_1_9_13 = RMEMHigh
parameters Rcell_0_1_9_14 = RMEMHigh
parameters Rcell_0_1_9_15 = RMEMHigh
parameters Rcell_0_1_10_0 = RMEMHigh
parameters Rcell_0_1_10_1 = RMEMLow
parameters Rcell_0_1_10_2 = RMEMLow
parameters Rcell_0_1_10_3 = RMEMHigh
parameters Rcell_0_1_10_4 = RMEMHigh
parameters Rcell_0_1_10_5 = RMEMLow
parameters Rcell_0_1_10_6 = RMEMHigh
parameters Rcell_0_1_10_7 = RMEMLow
parameters Rcell_0_1_10_8 = RMEMLow
parameters Rcell_0_1_10_9 = RMEMLow
parameters Rcell_0_1_10_10 = RMEMLow
parameters Rcell_0_1_10_11 = RMEMHigh
parameters Rcell_0_1_10_12 = RMEMLow
parameters Rcell_0_1_10_13 = RMEMLow
parameters Rcell_0_1_10_14 = RMEMHigh
parameters Rcell_0_1_10_15 = RMEMLow
parameters Rcell_0_1_11_0 = RMEMLow
parameters Rcell_0_1_11_1 = RMEMLow
parameters Rcell_0_1_11_2 = RMEMHigh
parameters Rcell_0_1_11_3 = RMEMLow
parameters Rcell_0_1_11_4 = RMEMHigh
parameters Rcell_0_1_11_5 = RMEMHigh
parameters Rcell_0_1_11_6 = RMEMHigh
parameters Rcell_0_1_11_7 = RMEMLow
parameters Rcell_0_1_11_8 = RMEMHigh
parameters Rcell_0_1_11_9 = RMEMHigh
parameters Rcell_0_1_11_10 = RMEMHigh
parameters Rcell_0_1_11_11 = RMEMHigh
parameters Rcell_0_1_11_12 = RMEMLow
parameters Rcell_0_1_11_13 = RMEMHigh
parameters Rcell_0_1_11_14 = RMEMLow
parameters Rcell_0_1_11_15 = RMEMHigh
parameters Rcell_0_1_12_0 = RMEMHigh
parameters Rcell_0_1_12_1 = RMEMLow
parameters Rcell_0_1_12_2 = RMEMHigh
parameters Rcell_0_1_12_3 = RMEMHigh
parameters Rcell_0_1_12_4 = RMEMLow
parameters Rcell_0_1_12_5 = RMEMHigh
parameters Rcell_0_1_12_6 = RMEMLow
parameters Rcell_0_1_12_7 = RMEMHigh
parameters Rcell_0_1_12_8 = RMEMLow
parameters Rcell_0_1_12_9 = RMEMLow
parameters Rcell_0_1_12_10 = RMEMLow
parameters Rcell_0_1_12_11 = RMEMLow
parameters Rcell_0_1_12_12 = RMEMHigh
parameters Rcell_0_1_12_13 = RMEMLow
parameters Rcell_0_1_12_14 = RMEMHigh
parameters Rcell_0_1_12_15 = RMEMLow
parameters Rcell_0_1_13_0 = RMEMHigh
parameters Rcell_0_1_13_1 = RMEMHigh
parameters Rcell_0_1_13_2 = RMEMHigh
parameters Rcell_0_1_13_3 = RMEMLow
parameters Rcell_0_1_13_4 = RMEMHigh
parameters Rcell_0_1_13_5 = RMEMHigh
parameters Rcell_0_1_13_6 = RMEMHigh
parameters Rcell_0_1_13_7 = RMEMLow
parameters Rcell_0_1_13_8 = RMEMLow
parameters Rcell_0_1_13_9 = RMEMHigh
parameters Rcell_0_1_13_10 = RMEMHigh
parameters Rcell_0_1_13_11 = RMEMHigh
parameters Rcell_0_1_13_12 = RMEMLow
parameters Rcell_0_1_13_13 = RMEMLow
parameters Rcell_0_1_13_14 = RMEMHigh
parameters Rcell_0_1_13_15 = RMEMLow
parameters Rcell_0_1_14_0 = RMEMHigh
parameters Rcell_0_1_14_1 = RMEMHigh
parameters Rcell_0_1_14_2 = RMEMLow
parameters Rcell_0_1_14_3 = RMEMLow
parameters Rcell_0_1_14_4 = RMEMHigh
parameters Rcell_0_1_14_5 = RMEMLow
parameters Rcell_0_1_14_6 = RMEMHigh
parameters Rcell_0_1_14_7 = RMEMHigh
parameters Rcell_0_1_14_8 = RMEMLow
parameters Rcell_0_1_14_9 = RMEMLow
parameters Rcell_0_1_14_10 = RMEMHigh
parameters Rcell_0_1_14_11 = RMEMLow
parameters Rcell_0_1_14_12 = RMEMLow
parameters Rcell_0_1_14_13 = RMEMLow
parameters Rcell_0_1_14_14 = RMEMLow
parameters Rcell_0_1_14_15 = RMEMHigh
parameters Rcell_0_1_15_0 = RMEMLow
parameters Rcell_0_1_15_1 = RMEMLow
parameters Rcell_0_1_15_2 = RMEMLow
parameters Rcell_0_1_15_3 = RMEMLow
parameters Rcell_0_1_15_4 = RMEMLow
parameters Rcell_0_1_15_5 = RMEMLow
parameters Rcell_0_1_15_6 = RMEMHigh
parameters Rcell_0_1_15_7 = RMEMLow
parameters Rcell_0_1_15_8 = RMEMHigh
parameters Rcell_0_1_15_9 = RMEMLow
parameters Rcell_0_1_15_10 = RMEMLow
parameters Rcell_0_1_15_11 = RMEMLow
parameters Rcell_0_1_15_12 = RMEMHigh
parameters Rcell_0_1_15_13 = RMEMHigh
parameters Rcell_0_1_15_14 = RMEMHigh
parameters Rcell_0_1_15_15 = RMEMHigh

parameters Rref_0 = RMEMHigh
parameters Rref_1 = RMEMHigh
parameters Rref_2 = RMEMHigh
parameters Rref_3 = RMEMHigh
parameters Rref_4 = RMEMHigh
parameters Rref_5 = RMEMHigh
parameters Rref_6 = RMEMHigh
parameters Rref_7 = RMEMHigh
parameters Rref_8 = RMEMLow
parameters Rref_9 = RMEMLow
parameters Rref_10 = RMEMLow
parameters Rref_11 = RMEMLow
parameters Rref_12 = RMEMLow
parameters Rref_13 = RMEMLow
parameters Rref_14 = RMEMLow
parameters Rref_15 = RMEMLow

parameters waveEnGB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53710000000002e-06 1 1.54100000000002e-06 1 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveEnLB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29905000000003e-06 0 2.30300000000003e-06 0 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68305000000004e-06 0 2.68700000000004e-06 0 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87505000000004e-06 0 2.87900000000004e-06 0 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97105000000004e-06 0 2.97500000000004e-06 0 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01905000000004e-06 0 3.02300000000004e-06 0 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04305000000004e-06 0 3.04700000000004e-06 0 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05505000000004e-06 0 3.05900000000004e-06 0 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06105000000004e-06 0 3.06500000000004e-06 0 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06705000000004e-06 0 3.07100000000004e-06 0 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveEnLB_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63049999999997e-07 0 7.66999999999997e-07 0 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.14705e-06 0 1.151e-06 0 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33905000000001e-06 0 1.34300000000001e-06 0 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43505000000001e-06 0 1.43900000000001e-06 0 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48305000000002e-06 0 1.48700000000002e-06 0 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50705000000002e-06 0 1.51100000000002e-06 0 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51905000000002e-06 0 1.52300000000002e-06 0 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52505000000002e-06 0 1.52900000000002e-06 0 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53105000000002e-06 0 1.53500000000002e-06 0 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53710000000002e-06 1 1.54100000000002e-06 1 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveBLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43505000000001e-06 0 1.43900000000001e-06 0 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97105000000004e-06 0 2.97500000000004e-06 0 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveBLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33905000000001e-06 0 1.34300000000001e-06 0 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87505000000004e-06 0 2.87900000000004e-06 0 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveBLstart_2=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.14705e-06 0 1.151e-06 0 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68305000000004e-06 0 2.68700000000004e-06 0 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveBLstart_3=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63049999999997e-07 0 7.66999999999997e-07 0 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29905000000003e-06 0 2.30300000000003e-06 0 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52505000000002e-06 0 1.52900000000002e-06 0 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06105000000004e-06 0 3.06500000000004e-06 0 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51905000000002e-06 0 1.52300000000002e-06 0 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05505000000004e-06 0 3.05900000000004e-06 0 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_2=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50705000000002e-06 0 1.51100000000002e-06 0 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04305000000004e-06 0 3.04700000000004e-06 0 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_3=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48305000000002e-06 0 1.48700000000002e-06 0 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01905000000004e-06 0 3.02300000000004e-06 0 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters wave_SA_SH = [0 0 3e-09 0 3.1e-09 1 4e-09 1 4.05e-09 0 6e-09 0 6.05e-09 0 9e-09 0 9.1e-09 1 1e-08 1 1.005e-08 0 1.2e-08 0 1.205e-08 0 1.5e-08 0 1.51e-08 1 1.6e-08 1 1.605e-08 0 1.8e-08 0 1.805e-08 0 2.1e-08 0 2.11e-08 1 2.2e-08 1 2.205e-08 0 2.4e-08 0 2.405e-08 0 2.7e-08 0 2.71e-08 1 2.8e-08 1 2.805e-08 0 3e-08 0 3.005e-08 0 3.3e-08 0 3.31e-08 1 3.4e-08 1 3.405e-08 0 3.6e-08 0 3.605e-08 0 3.9e-08 0 3.91e-08 1 4e-08 1 4.005e-08 0 4.2e-08 0 4.205e-08 0 4.5e-08 0 4.51e-08 1 4.6e-08 1 4.605e-08 0 4.8e-08 0 4.805e-08 0 5.1e-08 0 5.11e-08 1 5.2e-08 1 5.205e-08 0 5.4e-08 0 5.405e-08 0 5.7e-08 0 5.71e-08 1 5.8e-08 1 5.805e-08 0 6e-08 0 6.005e-08 0 6.3e-08 0 6.31e-08 1 6.4e-08 1 6.405e-08 0 6.6e-08 0 6.605e-08 0 6.9e-08 0 6.91e-08 1 7e-08 1 7.005e-08 0 7.2e-08 0 7.205e-08 0 7.5e-08 0 7.51e-08 1 7.6e-08 1 7.605e-08 0 7.8e-08 0 7.805e-08 0 8.1e-08 0 8.11e-08 1 8.2e-08 1 8.205e-08 0 8.4e-08 0 8.405e-08 0 8.7e-08 0 8.71e-08 1 8.8e-08 1 8.805e-08 0 9e-08 0 9.005e-08 0 9.3e-08 0 9.31e-08 1 9.4e-08 1 9.405e-08 0 9.6e-08 0 9.605e-08 0 9.9e-08 0 9.91e-08 1 1e-07 1 1.0005e-07 0 1.02e-07 0 1.0205e-07 0 1.05e-07 0 1.051e-07 1 1.06e-07 1 1.0605e-07 0 1.08e-07 0 1.0805e-07 0 1.11e-07 0 1.111e-07 1 1.12e-07 1 1.1205e-07 0 1.14e-07 0 1.1405e-07 0 1.17e-07 0 1.171e-07 1 1.18e-07 1 1.1805e-07 0 1.2e-07 0 1.2005e-07 0 1.23e-07 0 1.231e-07 1 1.24e-07 1 1.2405e-07 0 1.26e-07 0 1.2605e-07 0 1.29e-07 0 1.291e-07 1 1.3e-07 1 1.3005e-07 0 1.32e-07 0 1.3205e-07 0 1.35e-07 0 1.351e-07 1 1.36e-07 1 1.3605e-07 0 1.38e-07 0 1.3805e-07 0 1.41e-07 0 1.411e-07 1 1.42e-07 1 1.4205e-07 0 1.44e-07 0 1.4405e-07 0 1.47e-07 0 1.471e-07 1 1.48e-07 1 1.4805e-07 0 1.5e-07 0 1.5005e-07 0 1.53e-07 0 1.531e-07 1 1.54e-07 1 1.5405e-07 0 1.56e-07 0 1.5605e-07 0 1.59e-07 0 1.591e-07 1 1.6e-07 1 1.6005e-07 0 1.62e-07 0 1.6205e-07 0 1.65e-07 0 1.651e-07 1 1.66e-07 1 1.6605e-07 0 1.68e-07 0 1.6805e-07 0 1.71e-07 0 1.711e-07 1 1.72e-07 1 1.7205e-07 0 1.74e-07 0 1.7405e-07 0 1.77e-07 0 1.771e-07 1 1.78e-07 1 1.7805e-07 0 1.8e-07 0 1.8005e-07 0 1.83e-07 0 1.831e-07 1 1.84e-07 1 1.8405e-07 0 1.86e-07 0 1.8605e-07 0 1.89e-07 0 1.891e-07 1 1.9e-07 1 1.9005e-07 0 1.92e-07 0 1.9205e-07 0 1.95e-07 0 1.951e-07 1 1.96e-07 1 1.9605e-07 0 1.98e-07 0 1.9805e-07 0 2.01e-07 0 2.011e-07 1 2.02e-07 1 2.0205e-07 0 2.04e-07 0 2.0405e-07 0 2.07e-07 0 2.071e-07 1 2.08e-07 1 2.0805e-07 0 2.1e-07 0 2.1005e-07 0 2.13e-07 0 2.131e-07 1 2.14e-07 1 2.1405e-07 0 2.16e-07 0 2.1605e-07 0 2.19e-07 0 2.191e-07 1 2.2e-07 1 2.2005e-07 0 2.22e-07 0 2.2205e-07 0 2.25e-07 0 2.251e-07 1 2.26e-07 1 2.2605e-07 0 2.28e-07 0 2.2805e-07 0 2.31e-07 0 2.311e-07 1 2.32e-07 1 2.3205e-07 0 2.34e-07 0 2.3405e-07 0 2.37e-07 0 2.371e-07 1 2.38e-07 1 2.3805e-07 0 2.4e-07 0 2.4005e-07 0 2.43e-07 0 2.431e-07 1 2.44e-07 1 2.4405e-07 0 2.46e-07 0 2.4605e-07 0 2.49e-07 0 2.491e-07 1 2.5e-07 1 2.5005e-07 0 2.52e-07 0 2.5205e-07 0 2.55e-07 0 2.551e-07 1 2.56e-07 1 2.5605e-07 0 2.58e-07 0 2.5805e-07 0 2.61e-07 0 2.611e-07 1 2.62e-07 1 2.6205e-07 0 2.64e-07 0 2.6405e-07 0 2.67e-07 0 2.671e-07 1 2.68e-07 1 2.6805e-07 0 2.7e-07 0 2.7005e-07 0 2.73e-07 0 2.731e-07 1 2.74e-07 1 2.7405e-07 0 2.76e-07 0 2.7605e-07 0 2.79e-07 0 2.791e-07 1 2.8e-07 1 2.8005e-07 0 2.82e-07 0 2.8205e-07 0 2.85e-07 0 2.851e-07 1 2.86e-07 1 2.8605e-07 0 2.88e-07 0 2.8805e-07 0 2.91e-07 0 2.911e-07 1 2.92e-07 1 2.9205e-07 0 2.94e-07 0 2.9405e-07 0 2.97e-07 0 2.971e-07 1 2.98e-07 1 2.9805e-07 0 3e-07 0 3.0005e-07 0 3.03e-07 0 3.031e-07 1 3.04e-07 1 3.0405e-07 0 3.06e-07 0 3.0605e-07 0 3.09e-07 0 3.091e-07 1 3.1e-07 1 3.1005e-07 0 3.12e-07 0 3.1205e-07 0 3.15e-07 0 3.151e-07 1 3.16e-07 1 3.1605e-07 0 3.18e-07 0 3.1805e-07 0 3.21e-07 0 3.211e-07 1 3.22e-07 1 3.2205e-07 0 3.24e-07 0 3.2405e-07 0 3.27e-07 0 3.271e-07 1 3.28e-07 1 3.2805e-07 0 3.3e-07 0 3.3005e-07 0 3.33e-07 0 3.331e-07 1 3.34e-07 1 3.3405e-07 0 3.36e-07 0 3.3605e-07 0 3.39e-07 0 3.391e-07 1 3.4e-07 1 3.4005e-07 0 3.42e-07 0 3.4205e-07 0 3.45e-07 0 3.451e-07 1 3.46e-07 1 3.4605e-07 0 3.48e-07 0 3.4805e-07 0 3.51e-07 0 3.511e-07 1 3.52e-07 1 3.5205e-07 0 3.54e-07 0 3.5405e-07 0 3.57e-07 0 3.571e-07 1 3.58e-07 1 3.5805e-07 0 3.6e-07 0 3.6005e-07 0 3.63e-07 0 3.631e-07 1 3.64e-07 1 3.6405e-07 0 3.66e-07 0 3.6605e-07 0 3.69e-07 0 3.691e-07 1 3.7e-07 1 3.7005e-07 0 3.72e-07 0 3.7205e-07 0 3.75e-07 0 3.751e-07 1 3.76e-07 1 3.7605e-07 0 3.78e-07 0 3.7805e-07 0 3.81e-07 0 3.811e-07 1 3.82e-07 1 3.8205e-07 0 3.84e-07 0 3.8405e-07 0 3.87e-07 0 3.871e-07 1 3.88e-07 1 3.8805e-07 0 3.9e-07 0 3.9005e-07 0 3.93e-07 0 3.931e-07 1 3.94e-07 1 3.9405e-07 0 3.96e-07 0 3.9605e-07 0 3.99e-07 0 3.991e-07 1 4e-07 1 4.0005e-07 0 4.02e-07 0 4.0205e-07 0 4.05e-07 0 4.051e-07 1 4.06e-07 1 4.0605e-07 0 4.08e-07 0 4.0805e-07 0 4.11e-07 0 4.111e-07 1 4.12e-07 1 4.1205e-07 0 4.14e-07 0 4.1405e-07 0 4.17e-07 0 4.171e-07 1 4.18e-07 1 4.1805e-07 0 4.2e-07 0 4.2005e-07 0 4.23e-07 0 4.231e-07 1 4.24e-07 1 4.2405e-07 0 4.26e-07 0 4.2605e-07 0 4.29e-07 0 4.291e-07 1 4.3e-07 1 4.3005e-07 0 4.32e-07 0 4.3205e-07 0 4.35e-07 0 4.351e-07 1 4.36e-07 1 4.3605e-07 0 4.38e-07 0 4.3805e-07 0 4.41e-07 0 4.411e-07 1 4.42e-07 1 4.4205e-07 0 4.44e-07 0 4.4405e-07 0 4.47e-07 0 4.47100000000001e-07 1 4.48000000000001e-07 1 4.48050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.53000000000001e-07 0 4.53100000000001e-07 1 4.54000000000001e-07 1 4.54050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.59000000000001e-07 0 4.59100000000001e-07 1 4.60000000000001e-07 1 4.60050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.65000000000001e-07 0 4.65100000000001e-07 1 4.66000000000001e-07 1 4.66050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.71000000000001e-07 0 4.71100000000001e-07 1 4.72000000000001e-07 1 4.72050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.77000000000001e-07 0 4.77100000000001e-07 1 4.78000000000001e-07 1 4.78050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.83000000000001e-07 0 4.83100000000001e-07 1 4.84000000000001e-07 1 4.84050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.89000000000001e-07 0 4.89100000000001e-07 1 4.90000000000001e-07 1 4.90050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.95000000000001e-07 0 4.95100000000001e-07 1 4.96000000000001e-07 1 4.96050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 5.01000000000001e-07 0 5.01100000000001e-07 1 5.02000000000001e-07 1 5.02050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.07000000000001e-07 0 5.07100000000001e-07 1 5.08000000000001e-07 1 5.08050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.13000000000001e-07 0 5.13100000000001e-07 1 5.14000000000001e-07 1 5.14050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.19000000000001e-07 0 5.19100000000001e-07 1 5.20000000000001e-07 1 5.20050000000001e-07 0 5.22000000000001e-07 0 5.22050000000001e-07 0 5.25000000000001e-07 0 5.25100000000001e-07 1 5.26000000000001e-07 1 5.26050000000001e-07 0 5.28000000000001e-07 0 5.28050000000001e-07 0 5.31000000000001e-07 0 5.31100000000001e-07 1 5.32000000000001e-07 1 5.32050000000001e-07 0 5.34000000000001e-07 0 5.34050000000001e-07 0 5.37000000000001e-07 0 5.37100000000001e-07 1 5.38000000000001e-07 1 5.38050000000001e-07 0 5.40000000000001e-07 0 5.40050000000001e-07 0 5.43000000000001e-07 0 5.43100000000001e-07 1 5.44000000000001e-07 1 5.44050000000001e-07 0 5.46000000000001e-07 0 5.46050000000001e-07 0 5.49000000000001e-07 0 5.49100000000001e-07 1 5.50000000000001e-07 1 5.50050000000001e-07 0 5.52000000000001e-07 0 5.52050000000001e-07 0 5.55000000000001e-07 0 5.55100000000001e-07 1 5.56000000000001e-07 1 5.56050000000001e-07 0 5.58000000000001e-07 0 5.58050000000001e-07 0 5.61000000000001e-07 0 5.61100000000001e-07 1 5.62000000000001e-07 1 5.62050000000001e-07 0 5.64000000000001e-07 0 5.64050000000001e-07 0 5.67000000000001e-07 0 5.67100000000001e-07 1 5.68000000000001e-07 1 5.68050000000001e-07 0 5.70000000000001e-07 0 5.70050000000001e-07 0 5.73000000000001e-07 0 5.73100000000001e-07 1 5.74000000000001e-07 1 5.74050000000001e-07 0 5.76000000000001e-07 0 5.76050000000001e-07 0 5.79000000000001e-07 0 5.79100000000001e-07 1 5.80000000000001e-07 1 5.80050000000001e-07 0 5.82000000000001e-07 0 5.82050000000001e-07 0 5.85000000000001e-07 0 5.85100000000001e-07 1 5.86000000000001e-07 1 5.86050000000001e-07 0 5.88000000000001e-07 0 5.88050000000001e-07 0 5.91000000000001e-07 0 5.91100000000001e-07 1 5.92000000000001e-07 1 5.92050000000001e-07 0 5.94000000000001e-07 0 5.94050000000001e-07 0 5.97000000000001e-07 0 5.97100000000001e-07 1 5.98000000000001e-07 1 5.98050000000001e-07 0 6.00000000000001e-07 0 6.00050000000001e-07 0 6.03000000000001e-07 0 6.03100000000001e-07 1 6.04000000000001e-07 1 6.04050000000001e-07 0 6.06000000000001e-07 0 6.06050000000001e-07 0 6.09000000000001e-07 0 6.09100000000001e-07 1 6.10000000000001e-07 1 6.10050000000001e-07 0 6.12000000000001e-07 0 6.12050000000001e-07 0 6.15000000000001e-07 0 6.15100000000001e-07 1 6.16000000000001e-07 1 6.16050000000001e-07 0 6.18000000000001e-07 0 6.18050000000001e-07 0 6.21000000000001e-07 0 6.21100000000001e-07 1 6.22000000000001e-07 1 6.22050000000001e-07 0 6.24000000000001e-07 0 6.24050000000001e-07 0 6.27000000000001e-07 0 6.27100000000001e-07 1 6.28000000000001e-07 1 6.28050000000001e-07 0 6.30000000000001e-07 0 6.30050000000001e-07 0 6.33000000000001e-07 0 6.33100000000001e-07 1 6.34000000000001e-07 1 6.34050000000001e-07 0 6.36000000000001e-07 0 6.36050000000001e-07 0 6.39000000000001e-07 0 6.39100000000001e-07 1 6.40000000000001e-07 1 6.40050000000001e-07 0 6.42000000000001e-07 0 6.42050000000001e-07 0 6.45000000000001e-07 0 6.45100000000001e-07 1 6.46000000000001e-07 1 6.46050000000001e-07 0 6.48000000000001e-07 0 6.48050000000001e-07 0 6.51000000000001e-07 0 6.51100000000001e-07 1 6.52000000000001e-07 1 6.52050000000001e-07 0 6.54000000000001e-07 0 6.54050000000001e-07 0 6.57000000000001e-07 0 6.57100000000001e-07 1 6.58000000000001e-07 1 6.58050000000001e-07 0 6.60000000000001e-07 0 6.60050000000001e-07 0 6.63000000000001e-07 0 6.63100000000001e-07 1 6.64000000000001e-07 1 6.64050000000001e-07 0 6.66000000000001e-07 0 6.66050000000001e-07 0 6.69000000000001e-07 0 6.69100000000001e-07 1 6.70000000000001e-07 1 6.70050000000001e-07 0 6.72000000000001e-07 0 6.72050000000001e-07 0 6.75000000000001e-07 0 6.75100000000001e-07 1 6.76000000000001e-07 1 6.76050000000001e-07 0 6.78000000000001e-07 0 6.78050000000001e-07 0 6.81000000000002e-07 0 6.81100000000002e-07 1 6.82000000000001e-07 1 6.82050000000001e-07 0 6.84000000000002e-07 0 6.84050000000002e-07 0 6.87000000000002e-07 0 6.87100000000002e-07 1 6.88000000000002e-07 1 6.88050000000002e-07 0 6.90000000000002e-07 0 6.90050000000002e-07 0 6.93000000000002e-07 0 6.93100000000002e-07 1 6.94000000000002e-07 1 6.94050000000002e-07 0 6.96000000000002e-07 0 6.96050000000002e-07 0 6.99000000000002e-07 0 6.99100000000002e-07 1 7.00000000000002e-07 1 7.00050000000002e-07 0 7.02000000000002e-07 0 7.02050000000002e-07 0 7.05000000000002e-07 0 7.05100000000002e-07 1 7.06000000000002e-07 1 7.06050000000002e-07 0 7.08000000000002e-07 0 7.08050000000002e-07 0 7.11000000000002e-07 0 7.11100000000002e-07 1 7.12000000000002e-07 1 7.12050000000002e-07 0 7.14000000000002e-07 0 7.14050000000002e-07 0 7.17000000000002e-07 0 7.17100000000002e-07 1 7.18000000000002e-07 1 7.18050000000002e-07 0 7.20000000000002e-07 0 7.20050000000002e-07 0 7.23000000000002e-07 0 7.23100000000002e-07 1 7.24000000000002e-07 1 7.24050000000002e-07 0 7.26000000000002e-07 0 7.26050000000002e-07 0 7.29000000000002e-07 0 7.29100000000002e-07 1 7.30000000000002e-07 1 7.30050000000002e-07 0 7.32000000000002e-07 0 7.32050000000002e-07 0 7.35000000000002e-07 0 7.35100000000002e-07 1 7.36000000000002e-07 1 7.36050000000002e-07 0 7.38000000000002e-07 0 7.38050000000002e-07 0 7.41000000000002e-07 0 7.41100000000002e-07 1 7.42000000000002e-07 1 7.42050000000002e-07 0 7.44000000000002e-07 0 7.44050000000002e-07 0 7.47000000000002e-07 0 7.47100000000002e-07 1 7.48000000000002e-07 1 7.48050000000002e-07 0 7.50000000000002e-07 0 7.50050000000002e-07 0 7.53000000000002e-07 0 7.53100000000002e-07 1 7.54000000000002e-07 1 7.54050000000002e-07 0 7.56000000000002e-07 0 7.56050000000002e-07 0 7.59000000000002e-07 0 7.59100000000002e-07 1 7.60000000000002e-07 1 7.60050000000002e-07 0 7.62000000000002e-07 0 7.62050000000002e-07 0 7.65000000000002e-07 0 7.65100000000002e-07 1 7.66000000000002e-07 1 7.66050000000002e-07 0 7.68000000000002e-07 0 7.68050000000002e-07 0 7.71000000000002e-07 0 7.71100000000002e-07 1 7.72000000000002e-07 1 7.72050000000002e-07 0 7.74000000000002e-07 0 7.74050000000002e-07 0 7.77000000000002e-07 0 7.77100000000002e-07 1 7.78000000000002e-07 1 7.78050000000002e-07 0 7.80000000000002e-07 0 7.80050000000002e-07 0 7.83000000000002e-07 0 7.83100000000002e-07 1 7.84000000000002e-07 1 7.84050000000002e-07 0 7.86000000000002e-07 0 7.86050000000002e-07 0 7.89000000000002e-07 0 7.89100000000002e-07 1 7.90000000000002e-07 1 7.90050000000002e-07 0 7.92000000000002e-07 0 7.92050000000002e-07 0 7.95000000000002e-07 0 7.95100000000002e-07 1 7.96000000000002e-07 1 7.96050000000002e-07 0 7.98000000000002e-07 0 7.98050000000002e-07 0 8.01000000000002e-07 0 8.01100000000002e-07 1 8.02000000000002e-07 1 8.02050000000002e-07 0 8.04000000000002e-07 0 8.04050000000002e-07 0 8.07000000000002e-07 0 8.07100000000002e-07 1 8.08000000000002e-07 1 8.08050000000002e-07 0 8.10000000000002e-07 0 8.10050000000002e-07 0 8.13000000000002e-07 0 8.13100000000002e-07 1 8.14000000000002e-07 1 8.14050000000002e-07 0 8.16000000000002e-07 0 8.16050000000002e-07 0 8.19000000000002e-07 0 8.19100000000002e-07 1 8.20000000000002e-07 1 8.20050000000002e-07 0 8.22000000000002e-07 0 8.22050000000002e-07 0 8.25000000000002e-07 0 8.25100000000002e-07 1 8.26000000000002e-07 1 8.26050000000002e-07 0 8.28000000000002e-07 0 8.28050000000002e-07 0 8.31000000000002e-07 0 8.31100000000002e-07 1 8.32000000000002e-07 1 8.32050000000002e-07 0 8.34000000000002e-07 0 8.34050000000002e-07 0 8.37000000000002e-07 0 8.37100000000002e-07 1 8.38000000000002e-07 1 8.38050000000002e-07 0 8.40000000000002e-07 0 8.40050000000002e-07 0 8.43000000000002e-07 0 8.43100000000002e-07 1 8.44000000000002e-07 1 8.44050000000002e-07 0 8.46000000000002e-07 0 8.46050000000002e-07 0 8.49000000000002e-07 0 8.49100000000002e-07 1 8.50000000000002e-07 1 8.50050000000002e-07 0 8.52000000000002e-07 0 8.52050000000002e-07 0 8.55000000000002e-07 0 8.55100000000002e-07 1 8.56000000000002e-07 1 8.56050000000002e-07 0 8.58000000000002e-07 0 8.58050000000002e-07 0 8.61000000000002e-07 0 8.61100000000002e-07 1 8.62000000000002e-07 1 8.62050000000002e-07 0 8.64000000000002e-07 0 8.64050000000002e-07 0 8.67000000000002e-07 0 8.67100000000002e-07 1 8.68000000000002e-07 1 8.68050000000002e-07 0 8.70000000000002e-07 0 8.70050000000002e-07 0 8.73000000000002e-07 0 8.73100000000002e-07 1 8.74000000000002e-07 1 8.74050000000002e-07 0 8.76000000000002e-07 0 8.76050000000002e-07 0 8.79000000000002e-07 0 8.79100000000002e-07 1 8.80000000000002e-07 1 8.80050000000002e-07 0 8.82000000000002e-07 0 8.82050000000002e-07 0 8.85000000000002e-07 0 8.85100000000002e-07 1 8.86000000000002e-07 1 8.86050000000002e-07 0 8.88000000000002e-07 0 8.88050000000002e-07 0 8.91000000000002e-07 0 8.91100000000002e-07 1 8.92000000000002e-07 1 8.92050000000002e-07 0 8.94000000000002e-07 0 8.94050000000002e-07 0 8.97000000000002e-07 0 8.97100000000002e-07 1 8.98000000000002e-07 1 8.98050000000002e-07 0 9.00000000000003e-07 0 9.00050000000003e-07 0 9.03000000000003e-07 0 9.03100000000003e-07 1 9.04000000000002e-07 1 9.04050000000002e-07 0 9.06000000000003e-07 0 9.06050000000003e-07 0 9.09000000000003e-07 0 9.09100000000003e-07 1 9.10000000000003e-07 1 9.10050000000003e-07 0 9.12000000000003e-07 0 9.12050000000003e-07 0 9.15000000000003e-07 0 9.15100000000003e-07 1 9.16000000000003e-07 1 9.16050000000003e-07 0 9.18000000000003e-07 0 9.18050000000003e-07 0 9.21000000000003e-07 0 9.21100000000003e-07 1 9.22000000000003e-07 1 9.22050000000003e-07 0 9.24000000000003e-07 0 9.24050000000003e-07 0 9.27000000000003e-07 0 9.27100000000003e-07 1 9.28000000000003e-07 1 9.28050000000003e-07 0 9.30000000000003e-07 0 9.30050000000003e-07 0 9.33000000000003e-07 0 9.33100000000003e-07 1 9.34000000000003e-07 1 9.34050000000003e-07 0 9.36000000000003e-07 0 9.36050000000003e-07 0 9.39000000000003e-07 0 9.39100000000003e-07 1 9.40000000000003e-07 1 9.40050000000003e-07 0 9.42000000000003e-07 0 9.42050000000003e-07 0 9.45000000000003e-07 0 9.45100000000003e-07 1 9.46000000000003e-07 1 9.46050000000003e-07 0 9.48000000000003e-07 0 9.48050000000003e-07 0 9.51000000000003e-07 0 9.51100000000003e-07 1 9.52000000000003e-07 1 9.52050000000003e-07 0 9.54000000000003e-07 0 9.54050000000003e-07 0 9.57000000000003e-07 0 9.57100000000003e-07 1 9.58000000000003e-07 1 9.58050000000003e-07 0 9.60000000000003e-07 0 9.60050000000003e-07 0 9.63000000000003e-07 0 9.63100000000003e-07 1 9.64000000000003e-07 1 9.64050000000003e-07 0 9.66000000000003e-07 0 9.66050000000003e-07 0 9.69000000000003e-07 0 9.69100000000003e-07 1 9.70000000000003e-07 1 9.70050000000003e-07 0 9.72000000000003e-07 0 9.72050000000003e-07 0 9.75000000000003e-07 0 9.75100000000003e-07 1 9.76000000000003e-07 1 9.76050000000003e-07 0 9.78000000000003e-07 0 9.78050000000003e-07 0 9.81000000000003e-07 0 9.81100000000003e-07 1 9.82000000000003e-07 1 9.82050000000003e-07 0 9.84000000000003e-07 0 9.84050000000003e-07 0 9.87000000000003e-07 0 9.87100000000003e-07 1 9.88000000000003e-07 1 9.88050000000003e-07 0 9.90000000000003e-07 0 9.90050000000003e-07 0 9.93000000000003e-07 0 9.93100000000003e-07 1 9.94000000000003e-07 1 9.94050000000003e-07 0 9.96000000000003e-07 0 9.96050000000003e-07 0 9.99000000000003e-07 0 9.99100000000003e-07 1 1e-06 1 1.00005e-06 0 1.002e-06 0 1.00205e-06 0 1.005e-06 0 1.0051e-06 1 1.006e-06 1 1.00605e-06 0 1.008e-06 0 1.00805e-06 0 1.011e-06 0 1.0111e-06 1 1.012e-06 1 1.01205e-06 0 1.014e-06 0 1.01405e-06 0 1.017e-06 0 1.0171e-06 1 1.018e-06 1 1.01805e-06 0 1.02e-06 0 1.02005e-06 0 1.023e-06 0 1.0231e-06 1 1.024e-06 1 1.02405e-06 0 1.026e-06 0 1.02605e-06 0 1.029e-06 0 1.0291e-06 1 1.03e-06 1 1.03005e-06 0 1.032e-06 0 1.03205e-06 0 1.035e-06 0 1.0351e-06 1 1.036e-06 1 1.03605e-06 0 1.038e-06 0 1.03805e-06 0 1.041e-06 0 1.0411e-06 1 1.042e-06 1 1.04205e-06 0 1.044e-06 0 1.04405e-06 0 1.047e-06 0 1.0471e-06 1 1.048e-06 1 1.04805e-06 0 1.05e-06 0 1.05005e-06 0 1.053e-06 0 1.0531e-06 1 1.054e-06 1 1.05405e-06 0 1.056e-06 0 1.05605e-06 0 1.059e-06 0 1.0591e-06 1 1.06e-06 1 1.06005e-06 0 1.062e-06 0 1.06205e-06 0 1.065e-06 0 1.0651e-06 1 1.066e-06 1 1.06605e-06 0 1.068e-06 0 1.06805e-06 0 1.071e-06 0 1.0711e-06 1 1.072e-06 1 1.07205e-06 0 1.074e-06 0 1.07405e-06 0 1.077e-06 0 1.0771e-06 1 1.078e-06 1 1.07805e-06 0 1.08e-06 0 1.08005e-06 0 1.083e-06 0 1.0831e-06 1 1.084e-06 1 1.08405e-06 0 1.086e-06 0 1.08605e-06 0 1.089e-06 0 1.0891e-06 1 1.09e-06 1 1.09005e-06 0 1.092e-06 0 1.09205e-06 0 1.095e-06 0 1.0951e-06 1 1.096e-06 1 1.09605e-06 0 1.098e-06 0 1.09805e-06 0 1.101e-06 0 1.1011e-06 1 1.102e-06 1 1.10205e-06 0 1.104e-06 0 1.10405e-06 0 1.107e-06 0 1.1071e-06 1 1.108e-06 1 1.10805e-06 0 1.11e-06 0 1.11005e-06 0 1.113e-06 0 1.1131e-06 1 1.114e-06 1 1.11405e-06 0 1.116e-06 0 1.11605e-06 0 1.119e-06 0 1.1191e-06 1 1.12e-06 1 1.12005e-06 0 1.122e-06 0 1.12205e-06 0 1.125e-06 0 1.1251e-06 1 1.126e-06 1 1.12605e-06 0 1.128e-06 0 1.12805e-06 0 1.131e-06 0 1.1311e-06 1 1.132e-06 1 1.13205e-06 0 1.134e-06 0 1.13405e-06 0 1.137e-06 0 1.1371e-06 1 1.138e-06 1 1.13805e-06 0 1.14e-06 0 1.14005e-06 0 1.143e-06 0 1.1431e-06 1 1.144e-06 1 1.14405e-06 0 1.146e-06 0 1.14605e-06 0 1.149e-06 0 1.1491e-06 1 1.15e-06 1 1.15005e-06 0 1.152e-06 0 1.15205e-06 0 1.155e-06 0 1.1551e-06 1 1.156e-06 1 1.15605e-06 0 1.158e-06 0 1.15805e-06 0 1.161e-06 0 1.1611e-06 1 1.162e-06 1 1.16205e-06 0 1.164e-06 0 1.16405e-06 0 1.167e-06 0 1.1671e-06 1 1.168e-06 1 1.16805e-06 0 1.17e-06 0 1.17005e-06 0 1.173e-06 0 1.1731e-06 1 1.174e-06 1 1.17405e-06 0 1.176e-06 0 1.17605e-06 0 1.179e-06 0 1.1791e-06 1 1.18e-06 1 1.18005e-06 0 1.182e-06 0 1.18205e-06 0 1.185e-06 0 1.1851e-06 1 1.186e-06 1 1.18605e-06 0 1.188e-06 0 1.18805e-06 0 1.191e-06 0 1.1911e-06 1 1.192e-06 1 1.19205e-06 0 1.194e-06 0 1.19405e-06 0 1.197e-06 0 1.1971e-06 1 1.198e-06 1 1.19805e-06 0 1.2e-06 0 1.20005e-06 0 1.203e-06 0 1.2031e-06 1 1.204e-06 1 1.20405e-06 0 1.206e-06 0 1.20605e-06 0 1.209e-06 0 1.2091e-06 1 1.21e-06 1 1.21005e-06 0 1.212e-06 0 1.21205e-06 0 1.215e-06 0 1.2151e-06 1 1.216e-06 1 1.21605e-06 0 1.218e-06 0 1.21805e-06 0 1.221e-06 0 1.2211e-06 1 1.222e-06 1 1.22205e-06 0 1.224e-06 0 1.22405e-06 0 1.227e-06 0 1.2271e-06 1 1.228e-06 1 1.22805e-06 0 1.23e-06 0 1.23005e-06 0 1.233e-06 0 1.2331e-06 1 1.234e-06 1 1.23405e-06 0 1.236e-06 0 1.23605e-06 0 1.239e-06 0 1.2391e-06 1 1.24e-06 1 1.24005e-06 0 1.242e-06 0 1.24205e-06 0 1.245e-06 0 1.2451e-06 1 1.246e-06 1 1.24605e-06 0 1.248e-06 0 1.24805e-06 0 1.251e-06 0 1.2511e-06 1 1.252e-06 1 1.25205e-06 0 1.254e-06 0 1.25405e-06 0 1.257e-06 0 1.2571e-06 1 1.258e-06 1 1.25805e-06 0 1.26e-06 0 1.26005e-06 0 1.263e-06 0 1.2631e-06 1 1.264e-06 1 1.26405e-06 0 1.266e-06 0 1.26605e-06 0 1.269e-06 0 1.2691e-06 1 1.27e-06 1 1.27005e-06 0 1.272e-06 0 1.27205e-06 0 1.275e-06 0 1.2751e-06 1 1.276e-06 1 1.27605e-06 0 1.278e-06 0 1.27805e-06 0 1.281e-06 0 1.2811e-06 1 1.282e-06 1 1.28205e-06 0 1.284e-06 0 1.28405e-06 0 1.287e-06 0 1.2871e-06 1 1.288e-06 1 1.28805e-06 0 1.29e-06 0 1.29005e-06 0 1.293e-06 0 1.2931e-06 1 1.294e-06 1 1.29405e-06 0 1.296e-06 0 1.29605e-06 0 1.299e-06 0 1.2991e-06 1 1.3e-06 1 1.30005e-06 0 1.302e-06 0 1.30205e-06 0 1.305e-06 0 1.3051e-06 1 1.306e-06 1 1.30605e-06 0 1.308e-06 0 1.30805e-06 0 1.311e-06 0 1.3111e-06 1 1.312e-06 1 1.31205e-06 0 1.314e-06 0 1.31405e-06 0 1.317e-06 0 1.3171e-06 1 1.318e-06 1 1.31805e-06 0 1.32e-06 0 1.32005e-06 0 1.323e-06 0 1.3231e-06 1 1.324e-06 1 1.32405e-06 0 1.326e-06 0 1.32605e-06 0 1.329e-06 0 1.3291e-06 1 1.33e-06 1 1.33005e-06 0 1.332e-06 0 1.33205e-06 0 1.335e-06 0 1.3351e-06 1 1.336e-06 1 1.33605e-06 0 1.338e-06 0 1.33805e-06 0 1.341e-06 0 1.3411e-06 1 1.342e-06 1 1.34205e-06 0 1.344e-06 0 1.34405e-06 0 1.347e-06 0 1.3471e-06 1 1.348e-06 1 1.34805e-06 0 1.35e-06 0 1.35005e-06 0 1.353e-06 0 1.3531e-06 1 1.354e-06 1 1.35405e-06 0 1.356e-06 0 1.35605e-06 0 1.359e-06 0 1.3591e-06 1 1.36e-06 1 1.36005e-06 0 1.362e-06 0 1.36205e-06 0 1.365e-06 0 1.3651e-06 1 1.366e-06 1 1.36605e-06 0 1.368e-06 0 1.36805e-06 0 1.371e-06 0 1.3711e-06 1 1.372e-06 1 1.37205e-06 0 1.374e-06 0 1.37405e-06 0 1.377e-06 0 1.3771e-06 1 1.378e-06 1 1.37805e-06 0 1.38e-06 0 1.38005e-06 0 1.383e-06 0 1.3831e-06 1 1.384e-06 1 1.38405e-06 0 1.386e-06 0 1.38605e-06 0 1.389e-06 0 1.3891e-06 1 1.39e-06 1 1.39005e-06 0 1.392e-06 0 1.39205e-06 0 1.395e-06 0 1.3951e-06 1 1.396e-06 1 1.39605e-06 0 1.398e-06 0 1.39805e-06 0 1.401e-06 0 1.4011e-06 1 1.402e-06 1 1.40205e-06 0 1.404e-06 0 1.40405e-06 0 1.407e-06 0 1.4071e-06 1 1.408e-06 1 1.40805e-06 0 1.41e-06 0 1.41005e-06 0 1.413e-06 0 1.4131e-06 1 1.414e-06 1 1.41405e-06 0 1.416e-06 0 1.41605e-06 0 1.419e-06 0 1.4191e-06 1 1.42e-06 1 1.42005e-06 0 1.422e-06 0 1.42205e-06 0 1.425e-06 0 1.4251e-06 1 1.426e-06 1 1.42605e-06 0 1.428e-06 0 1.42805e-06 0 1.431e-06 0 1.4311e-06 1 1.432e-06 1 1.43205e-06 0 1.434e-06 0 1.43405e-06 0 1.437e-06 0 1.4371e-06 1 1.438e-06 1 1.43805e-06 0 1.44e-06 0 1.44005e-06 0 1.443e-06 0 1.4431e-06 1 1.444e-06 1 1.44405e-06 0 1.446e-06 0 1.44605e-06 0 1.449e-06 0 1.4491e-06 1 1.45e-06 1 1.45005e-06 0 1.452e-06 0 1.45205e-06 0 1.455e-06 0 1.4551e-06 1 1.456e-06 1 1.45605e-06 0 1.458e-06 0 1.45805e-06 0 1.461e-06 0 1.4611e-06 1 1.46200000000001e-06 1 1.46205e-06 0 1.464e-06 0 1.46405e-06 0 1.467e-06 0 1.4671e-06 1 1.46800000000001e-06 1 1.46805e-06 0 1.47e-06 0 1.47005e-06 0 1.473e-06 0 1.47310000000001e-06 1 1.47400000000001e-06 1 1.47405e-06 0 1.47600000000001e-06 0 1.47605e-06 0 1.47900000000001e-06 0 1.47910000000001e-06 1 1.48000000000001e-06 1 1.48005e-06 0 1.48200000000001e-06 0 1.48205e-06 0 1.48500000000001e-06 0 1.48510000000001e-06 1 1.48600000000001e-06 1 1.48605000000001e-06 0 1.48800000000001e-06 0 1.48805e-06 0 1.49100000000001e-06 0 1.49110000000001e-06 1 1.49200000000001e-06 1 1.49205000000001e-06 0 1.49400000000001e-06 0 1.49405e-06 0 1.49700000000001e-06 0 1.49710000000001e-06 1 1.49800000000001e-06 1 1.49805000000001e-06 0 1.50000000000001e-06 0 1.50005000000001e-06 0 1.50300000000001e-06 0 1.50310000000001e-06 1 1.50400000000001e-06 1 1.50405000000001e-06 0 1.50600000000001e-06 0 1.50605000000001e-06 0 1.50900000000001e-06 0 1.50910000000001e-06 1 1.51000000000001e-06 1 1.51005000000001e-06 0 1.51200000000001e-06 0 1.51205000000001e-06 0 1.51500000000001e-06 0 1.51510000000001e-06 1 1.51600000000001e-06 1 1.51605000000001e-06 0 1.51800000000001e-06 0 1.51805000000001e-06 0 1.52100000000001e-06 0 1.52110000000001e-06 1 1.52200000000001e-06 1 1.52205000000001e-06 0 1.52400000000001e-06 0 1.52405000000001e-06 0 1.52700000000001e-06 0 1.52710000000001e-06 1 1.52800000000001e-06 1 1.52805000000001e-06 0 1.53000000000001e-06 0 1.53005000000001e-06 0 1.53300000000001e-06 0 1.53310000000001e-06 1 1.53400000000001e-06 1 1.53405000000001e-06 0 1.53600000000001e-06 0 1.53605000000001e-06 0 1.53900000000001e-06 0 1.53910000000001e-06 1 1.54000000000001e-06 1 1.54005000000001e-06 0 1.54200000000001e-06 0 1.54205000000001e-06 0 1.54500000000001e-06 0 1.54510000000001e-06 1 1.54600000000001e-06 1 1.54605000000001e-06 0 1.54800000000001e-06 0 1.54805000000001e-06 0 1.55100000000001e-06 0 1.55110000000001e-06 1 1.55200000000001e-06 1 1.55205000000001e-06 0 1.55400000000001e-06 0 1.55405000000001e-06 0 1.55700000000001e-06 0 1.55710000000001e-06 1 1.55800000000001e-06 1 1.55805000000001e-06 0 1.56000000000001e-06 0 1.56005000000001e-06 0 1.56300000000001e-06 0 1.56310000000001e-06 1 1.56400000000001e-06 1 1.56405000000001e-06 0 1.56600000000001e-06 0 1.56605000000001e-06 0 1.56900000000001e-06 0 1.56910000000001e-06 1 1.57000000000001e-06 1 1.57005000000001e-06 0 1.57200000000001e-06 0 1.57205000000001e-06 0 1.57500000000001e-06 0 1.57510000000001e-06 1 1.57600000000001e-06 1 1.57605000000001e-06 0 1.57800000000001e-06 0 1.57805000000001e-06 0 1.58100000000001e-06 0 1.58110000000001e-06 1 1.58200000000001e-06 1 1.58205000000001e-06 0 1.58400000000001e-06 0 1.58405000000001e-06 0 1.58700000000001e-06 0 1.58710000000001e-06 1 1.58800000000001e-06 1 1.58805000000001e-06 0 1.59000000000001e-06 0 1.59005000000001e-06 0 1.59300000000001e-06 0 1.59310000000001e-06 1 1.59400000000001e-06 1 1.59405000000001e-06 0 1.59600000000001e-06 0 1.59605000000001e-06 0 1.59900000000001e-06 0 1.59910000000001e-06 1 1.60000000000001e-06 1 1.60005000000001e-06 0 1.60200000000001e-06 0 1.60205000000001e-06 0 1.60500000000001e-06 0 1.60510000000001e-06 1 1.60600000000001e-06 1 1.60605000000001e-06 0 1.60800000000001e-06 0 1.60805000000001e-06 0 1.61100000000001e-06 0 1.61110000000001e-06 1 1.61200000000001e-06 1 1.61205000000001e-06 0 1.61400000000001e-06 0 1.61405000000001e-06 0 1.61700000000001e-06 0 1.61710000000001e-06 1 1.61800000000001e-06 1 1.61805000000001e-06 0 1.62000000000001e-06 0 1.62005000000001e-06 0 1.62300000000001e-06 0 1.62310000000001e-06 1 1.62400000000001e-06 1 1.62405000000001e-06 0 1.62600000000001e-06 0 1.62605000000001e-06 0 1.62900000000001e-06 0 1.62910000000001e-06 1 1.63000000000001e-06 1 1.63005000000001e-06 0 1.63200000000001e-06 0 1.63205000000001e-06 0 1.63500000000001e-06 0 1.63510000000001e-06 1 1.63600000000001e-06 1 1.63605000000001e-06 0 1.63800000000001e-06 0 1.63805000000001e-06 0 1.64100000000001e-06 0 1.64110000000001e-06 1 1.64200000000001e-06 1 1.64205000000001e-06 0 1.64400000000001e-06 0 1.64405000000001e-06 0 1.64700000000001e-06 0 1.64710000000001e-06 1 1.64800000000001e-06 1 1.64805000000001e-06 0 1.65000000000001e-06 0 1.65005000000001e-06 0 1.65300000000001e-06 0 1.65310000000001e-06 1 1.65400000000001e-06 1 1.65405000000001e-06 0 1.65600000000001e-06 0 1.65605000000001e-06 0 1.65900000000001e-06 0 1.65910000000001e-06 1 1.66000000000001e-06 1 1.66005000000001e-06 0 1.66200000000001e-06 0 1.66205000000001e-06 0 1.66500000000001e-06 0 1.66510000000001e-06 1 1.66600000000001e-06 1 1.66605000000001e-06 0 1.66800000000001e-06 0 1.66805000000001e-06 0 1.67100000000001e-06 0 1.67110000000001e-06 1 1.67200000000001e-06 1 1.67205000000001e-06 0 1.67400000000001e-06 0 1.67405000000001e-06 0 1.67700000000001e-06 0 1.67710000000001e-06 1 1.67800000000001e-06 1 1.67805000000001e-06 0 1.68000000000001e-06 0 1.68005000000001e-06 0 1.68300000000001e-06 0 1.68310000000001e-06 1 1.68400000000001e-06 1 1.68405000000001e-06 0 1.68600000000001e-06 0 1.68605000000001e-06 0 1.68900000000001e-06 0 1.68910000000001e-06 1 1.69000000000001e-06 1 1.69005000000001e-06 0 1.69200000000001e-06 0 1.69205000000001e-06 0 1.69500000000001e-06 0 1.69510000000001e-06 1 1.69600000000001e-06 1 1.69605000000001e-06 0 1.69800000000001e-06 0 1.69805000000001e-06 0 1.70100000000001e-06 0 1.70110000000001e-06 1 1.70200000000001e-06 1 1.70205000000001e-06 0 1.70400000000001e-06 0 1.70405000000001e-06 0 1.70700000000001e-06 0 1.70710000000001e-06 1 1.70800000000001e-06 1 1.70805000000001e-06 0 1.71000000000001e-06 0 1.71005000000001e-06 0 1.71300000000001e-06 0 1.71310000000001e-06 1 1.71400000000001e-06 1 1.71405000000001e-06 0 1.71600000000001e-06 0 1.71605000000001e-06 0 1.71900000000001e-06 0 1.71910000000001e-06 1 1.72000000000001e-06 1 1.72005000000001e-06 0 1.72200000000001e-06 0 1.72205000000001e-06 0 1.72500000000001e-06 0 1.72510000000001e-06 1 1.72600000000001e-06 1 1.72605000000001e-06 0 1.72800000000001e-06 0 1.72805000000001e-06 0 1.73100000000001e-06 0 1.73110000000001e-06 1 1.73200000000001e-06 1 1.73205000000001e-06 0 1.73400000000001e-06 0 1.73405000000001e-06 0 1.73700000000001e-06 0 1.73710000000001e-06 1 1.73800000000001e-06 1 1.73805000000001e-06 0 1.74000000000001e-06 0 1.74005000000001e-06 0 1.74300000000001e-06 0 1.74310000000001e-06 1 1.74400000000001e-06 1 1.74405000000001e-06 0 1.74600000000001e-06 0 1.74605000000001e-06 0 1.74900000000001e-06 0 1.74910000000001e-06 1 1.75000000000001e-06 1 1.75005000000001e-06 0 1.75200000000001e-06 0 1.75205000000001e-06 0 1.75500000000001e-06 0 1.75510000000001e-06 1 1.75600000000001e-06 1 1.75605000000001e-06 0 1.75800000000001e-06 0 1.75805000000001e-06 0 1.76100000000001e-06 0 1.76110000000001e-06 1 1.76200000000001e-06 1 1.76205000000001e-06 0 1.76400000000001e-06 0 1.76405000000001e-06 0 1.76700000000001e-06 0 1.76710000000001e-06 1 1.76800000000001e-06 1 1.76805000000001e-06 0 1.77000000000001e-06 0 1.77005000000001e-06 0 1.77300000000001e-06 0 1.77310000000001e-06 1 1.77400000000001e-06 1 1.77405000000001e-06 0 1.77600000000001e-06 0 1.77605000000001e-06 0 1.77900000000001e-06 0 1.77910000000001e-06 1 1.78000000000001e-06 1 1.78005000000001e-06 0 1.78200000000001e-06 0 1.78205000000001e-06 0 1.78500000000001e-06 0 1.78510000000001e-06 1 1.78600000000001e-06 1 1.78605000000001e-06 0 1.78800000000001e-06 0 1.78805000000001e-06 0 1.79100000000001e-06 0 1.79110000000001e-06 1 1.79200000000001e-06 1 1.79205000000001e-06 0 1.79400000000001e-06 0 1.79405000000001e-06 0 1.79700000000001e-06 0 1.79710000000001e-06 1 1.79800000000001e-06 1 1.79805000000001e-06 0 1.80000000000001e-06 0 1.80005000000001e-06 0 1.80300000000001e-06 0 1.80310000000001e-06 1 1.80400000000001e-06 1 1.80405000000001e-06 0 1.80600000000001e-06 0 1.80605000000001e-06 0 1.80900000000001e-06 0 1.80910000000001e-06 1 1.81000000000001e-06 1 1.81005000000001e-06 0 1.81200000000001e-06 0 1.81205000000001e-06 0 1.81500000000001e-06 0 1.81510000000001e-06 1 1.81600000000001e-06 1 1.81605000000001e-06 0 1.81800000000001e-06 0 1.81805000000001e-06 0 1.82100000000001e-06 0 1.82110000000001e-06 1 1.82200000000001e-06 1 1.82205000000001e-06 0 1.82400000000001e-06 0 1.82405000000001e-06 0 1.82700000000001e-06 0 1.82710000000001e-06 1 1.82800000000001e-06 1 1.82805000000001e-06 0 1.83000000000001e-06 0 1.83005000000001e-06 0 1.83300000000001e-06 0 1.83310000000001e-06 1 1.83400000000001e-06 1 1.83405000000001e-06 0 1.83600000000001e-06 0 1.83605000000001e-06 0 1.83900000000001e-06 0 1.83910000000001e-06 1 1.84000000000001e-06 1 1.84005000000001e-06 0 1.84200000000001e-06 0 1.84205000000001e-06 0 1.84500000000001e-06 0 1.84510000000001e-06 1 1.84600000000001e-06 1 1.84605000000001e-06 0 1.84800000000001e-06 0 1.84805000000001e-06 0 1.85100000000001e-06 0 1.85110000000001e-06 1 1.85200000000001e-06 1 1.85205000000001e-06 0 1.85400000000001e-06 0 1.85405000000001e-06 0 1.85700000000001e-06 0 1.85710000000001e-06 1 1.85800000000001e-06 1 1.85805000000001e-06 0 1.86000000000001e-06 0 1.86005000000001e-06 0 1.86300000000001e-06 0 1.86310000000001e-06 1 1.86400000000001e-06 1 1.86405000000001e-06 0 1.86600000000001e-06 0 1.86605000000001e-06 0 1.86900000000001e-06 0 1.86910000000001e-06 1 1.87000000000001e-06 1 1.87005000000001e-06 0 1.87200000000001e-06 0 1.87205000000001e-06 0 1.87500000000001e-06 0 1.87510000000001e-06 1 1.87600000000001e-06 1 1.87605000000001e-06 0 1.87800000000001e-06 0 1.87805000000001e-06 0 1.88100000000001e-06 0 1.88110000000001e-06 1 1.88200000000001e-06 1 1.88205000000001e-06 0 1.88400000000001e-06 0 1.88405000000001e-06 0 1.88700000000001e-06 0 1.88710000000001e-06 1 1.88800000000001e-06 1 1.88805000000001e-06 0 1.89000000000001e-06 0 1.89005000000001e-06 0 1.89300000000001e-06 0 1.89310000000001e-06 1 1.89400000000001e-06 1 1.89405000000001e-06 0 1.89600000000001e-06 0 1.89605000000001e-06 0 1.89900000000001e-06 0 1.89910000000001e-06 1 1.90000000000001e-06 1 1.90005000000001e-06 0 1.90200000000001e-06 0 1.90205000000001e-06 0 1.90500000000001e-06 0 1.90510000000001e-06 1 1.90600000000001e-06 1 1.90605000000001e-06 0 1.90800000000001e-06 0 1.90805000000001e-06 0 1.91100000000001e-06 0 1.91110000000001e-06 1 1.91200000000001e-06 1 1.91205000000001e-06 0 1.91400000000001e-06 0 1.91405000000001e-06 0 1.91700000000001e-06 0 1.91710000000001e-06 1 1.91800000000001e-06 1 1.91805000000001e-06 0 1.92000000000001e-06 0 1.92005000000001e-06 0 1.92300000000001e-06 0 1.92310000000001e-06 1 1.92400000000001e-06 1 1.92405000000001e-06 0 1.92600000000001e-06 0 1.92605000000001e-06 0 1.92900000000001e-06 0 1.92910000000001e-06 1 1.93000000000001e-06 1 1.93005000000001e-06 0 1.93200000000001e-06 0 1.93205000000001e-06 0 1.93500000000001e-06 0 1.93510000000001e-06 1 1.93600000000001e-06 1 1.93605000000001e-06 0 1.93800000000001e-06 0 1.93805000000001e-06 0 1.94100000000001e-06 0 1.94110000000001e-06 1 1.94200000000001e-06 1 1.94205000000001e-06 0 1.94400000000001e-06 0 1.94405000000001e-06 0 1.94700000000001e-06 0 1.94710000000001e-06 1 1.94800000000001e-06 1 1.94805000000001e-06 0 1.95000000000001e-06 0 1.95005000000001e-06 0 1.95300000000001e-06 0 1.95310000000001e-06 1 1.95400000000001e-06 1 1.95405000000001e-06 0 1.95600000000001e-06 0 1.95605000000001e-06 0 1.95900000000001e-06 0 1.95910000000001e-06 1 1.96000000000001e-06 1 1.96005000000001e-06 0 1.96200000000001e-06 0 1.96205000000001e-06 0 1.96500000000001e-06 0 1.96510000000001e-06 1 1.96600000000001e-06 1 1.96605000000001e-06 0 1.96800000000001e-06 0 1.96805000000001e-06 0 1.97100000000001e-06 0 1.97110000000001e-06 1 1.97200000000001e-06 1 1.97205000000001e-06 0 1.97400000000001e-06 0 1.97405000000001e-06 0 1.97700000000001e-06 0 1.97710000000001e-06 1 1.97800000000001e-06 1 1.97805000000001e-06 0 1.98000000000001e-06 0 1.98005000000001e-06 0 1.98300000000001e-06 0 1.98310000000001e-06 1 1.98400000000001e-06 1 1.98405000000001e-06 0 1.98600000000001e-06 0 1.98605000000001e-06 0 1.98900000000001e-06 0 1.98910000000001e-06 1 1.99000000000001e-06 1 1.99005000000001e-06 0 1.99200000000001e-06 0 1.99205000000001e-06 0 1.99500000000001e-06 0 1.99510000000001e-06 1 1.99600000000001e-06 1 1.99605000000001e-06 0 1.99800000000001e-06 0 1.99805000000001e-06 0 2.00100000000001e-06 0 2.00110000000001e-06 1 2.00200000000001e-06 1 2.00205000000001e-06 0 2.00400000000001e-06 0 2.00405000000001e-06 0 2.00700000000001e-06 0 2.00710000000001e-06 1 2.00800000000001e-06 1 2.00805000000001e-06 0 2.01000000000001e-06 0 2.01005000000001e-06 0 2.01300000000001e-06 0 2.01310000000001e-06 1 2.01400000000001e-06 1 2.01405000000001e-06 0 2.01600000000001e-06 0 2.01605000000001e-06 0 2.01900000000001e-06 0 2.01910000000001e-06 1 2.02000000000001e-06 1 2.02005000000001e-06 0 2.02200000000001e-06 0 2.02205000000001e-06 0 2.02500000000001e-06 0 2.02510000000001e-06 1 2.02600000000001e-06 1 2.02605000000001e-06 0 2.02800000000001e-06 0 2.02805000000001e-06 0 2.03100000000001e-06 0 2.03110000000001e-06 1 2.03200000000001e-06 1 2.03205000000001e-06 0 2.03400000000001e-06 0 2.03405000000001e-06 0 2.03700000000001e-06 0 2.03710000000001e-06 1 2.03800000000001e-06 1 2.03805000000001e-06 0 2.04000000000001e-06 0 2.04005000000001e-06 0 2.04300000000001e-06 0 2.04310000000001e-06 1 2.04400000000001e-06 1 2.04405000000001e-06 0 2.04600000000001e-06 0 2.04605000000001e-06 0 2.04900000000001e-06 0 2.04910000000001e-06 1 2.05000000000001e-06 1 2.05005000000001e-06 0 2.05200000000001e-06 0 2.05205000000001e-06 0 2.05500000000001e-06 0 2.05510000000001e-06 1 2.05600000000001e-06 1 2.05605000000001e-06 0 2.05800000000001e-06 0 2.05805000000001e-06 0 2.06100000000001e-06 0 2.06110000000001e-06 1 2.06200000000001e-06 1 2.06205000000001e-06 0 2.06400000000001e-06 0 2.06405000000001e-06 0 2.06700000000001e-06 0 2.06710000000001e-06 1 2.06800000000001e-06 1 2.06805000000001e-06 0 2.07000000000001e-06 0 2.07005000000001e-06 0 2.07300000000001e-06 0 2.07310000000001e-06 1 2.07400000000001e-06 1 2.07405000000001e-06 0 2.07600000000001e-06 0 2.07605000000001e-06 0 2.07900000000001e-06 0 2.07910000000001e-06 1 2.08000000000001e-06 1 2.08005000000001e-06 0 2.08200000000001e-06 0 2.08205000000001e-06 0 2.08500000000001e-06 0 2.08510000000001e-06 1 2.08600000000001e-06 1 2.08605000000001e-06 0 2.08800000000001e-06 0 2.08805000000001e-06 0 2.09100000000001e-06 0 2.09110000000001e-06 1 2.09200000000001e-06 1 2.09205000000001e-06 0 2.09400000000001e-06 0 2.09405000000001e-06 0 2.09700000000001e-06 0 2.09710000000001e-06 1 2.09800000000001e-06 1 2.09805000000001e-06 0 2.10000000000001e-06 0 2.10005000000001e-06 0 2.10300000000001e-06 0 2.10310000000001e-06 1 2.10400000000001e-06 1 2.10405000000001e-06 0 2.10600000000001e-06 0 2.10605000000001e-06 0 2.10900000000001e-06 0 2.10910000000001e-06 1 2.11000000000001e-06 1 2.11005000000001e-06 0 2.11200000000001e-06 0 2.11205000000001e-06 0 2.11500000000001e-06 0 2.11510000000001e-06 1 2.11600000000001e-06 1 2.11605000000001e-06 0 2.11800000000001e-06 0 2.11805000000001e-06 0 2.12100000000001e-06 0 2.12110000000001e-06 1 2.12200000000001e-06 1 2.12205000000001e-06 0 2.12400000000001e-06 0 2.12405000000001e-06 0 2.12700000000001e-06 0 2.12710000000001e-06 1 2.12800000000001e-06 1 2.12805000000001e-06 0 2.13000000000001e-06 0 2.13005000000001e-06 0 2.13300000000001e-06 0 2.13310000000001e-06 1 2.13400000000001e-06 1 2.13405000000001e-06 0 2.13600000000001e-06 0 2.13605000000001e-06 0 2.13900000000001e-06 0 2.13910000000001e-06 1 2.14000000000001e-06 1 2.14005000000001e-06 0 2.14200000000001e-06 0 2.14205000000001e-06 0 2.14500000000001e-06 0 2.14510000000001e-06 1 2.14600000000001e-06 1 2.14605000000001e-06 0 2.14800000000001e-06 0 2.14805000000001e-06 0 2.15100000000001e-06 0 2.15110000000001e-06 1 2.15200000000001e-06 1 2.15205000000001e-06 0 2.15400000000001e-06 0 2.15405000000001e-06 0 2.15700000000001e-06 0 2.15710000000001e-06 1 2.15800000000001e-06 1 2.15805000000001e-06 0 2.16000000000001e-06 0 2.16005000000001e-06 0 2.16300000000001e-06 0 2.16310000000001e-06 1 2.16400000000001e-06 1 2.16405000000001e-06 0 2.16600000000001e-06 0 2.16605000000001e-06 0 2.16900000000001e-06 0 2.16910000000001e-06 1 2.17000000000001e-06 1 2.17005000000001e-06 0 2.17200000000001e-06 0 2.17205000000001e-06 0 2.17500000000001e-06 0 2.17510000000001e-06 1 2.17600000000001e-06 1 2.17605000000001e-06 0 2.17800000000001e-06 0 2.17805000000001e-06 0 2.18100000000001e-06 0 2.18110000000001e-06 1 2.18200000000001e-06 1 2.18205000000001e-06 0 2.18400000000001e-06 0 2.18405000000001e-06 0 2.18700000000001e-06 0 2.18710000000001e-06 1 2.18800000000001e-06 1 2.18805000000001e-06 0 2.19000000000001e-06 0 2.19005000000001e-06 0 2.19300000000001e-06 0 2.19310000000001e-06 1 2.19400000000001e-06 1 2.19405000000001e-06 0 2.19600000000001e-06 0 2.19605000000001e-06 0 2.19900000000001e-06 0 2.19910000000001e-06 1 2.20000000000001e-06 1 2.20005000000001e-06 0 2.20200000000001e-06 0 2.20205000000001e-06 0 2.20500000000001e-06 0 2.20510000000001e-06 1 2.20600000000001e-06 1 2.20605000000001e-06 0 2.20800000000001e-06 0 2.20805000000001e-06 0 2.21100000000001e-06 0 2.21110000000001e-06 1 2.21200000000001e-06 1 2.21205000000001e-06 0 2.21400000000001e-06 0 2.21405000000001e-06 0 2.21700000000001e-06 0 2.21710000000001e-06 1 2.21800000000001e-06 1 2.21805000000001e-06 0 2.22000000000001e-06 0 2.22005000000001e-06 0 2.22300000000001e-06 0 2.22310000000001e-06 1 2.22400000000001e-06 1 2.22405000000001e-06 0 2.22600000000001e-06 0 2.22605000000001e-06 0 2.22900000000001e-06 0 2.22910000000001e-06 1 2.23000000000001e-06 1 2.23005000000001e-06 0 2.23200000000001e-06 0 2.23205000000001e-06 0 2.23500000000001e-06 0 2.23510000000001e-06 1 2.23600000000001e-06 1 2.23605000000001e-06 0 2.23800000000001e-06 0 2.23805000000001e-06 0 2.24100000000001e-06 0 2.24110000000001e-06 1 2.24200000000001e-06 1 2.24205000000001e-06 0 2.24400000000001e-06 0 2.24405000000001e-06 0 2.24700000000001e-06 0 2.24710000000001e-06 1 2.24800000000001e-06 1 2.24805000000001e-06 0 2.25000000000001e-06 0 2.25005000000001e-06 0 2.25300000000001e-06 0 2.25310000000001e-06 1 2.25400000000001e-06 1 2.25405000000001e-06 0 2.25600000000001e-06 0 2.25605000000001e-06 0 2.25900000000001e-06 0 2.25910000000001e-06 1 2.26000000000001e-06 1 2.26005000000001e-06 0 2.26200000000001e-06 0 2.26205000000001e-06 0 2.26500000000001e-06 0 2.26510000000001e-06 1 2.26600000000001e-06 1 2.26605000000001e-06 0 2.26800000000001e-06 0 2.26805000000001e-06 0 2.27100000000001e-06 0 2.27110000000001e-06 1 2.27200000000001e-06 1 2.27205000000001e-06 0 2.27400000000001e-06 0 2.27405000000001e-06 0 2.27700000000001e-06 0 2.27710000000001e-06 1 2.27800000000001e-06 1 2.27805000000001e-06 0 2.28000000000001e-06 0 2.28005000000001e-06 0 2.28300000000001e-06 0 2.28310000000001e-06 1 2.28400000000001e-06 1 2.28405000000001e-06 0 2.28600000000001e-06 0 2.28605000000001e-06 0 2.28900000000001e-06 0 2.28910000000001e-06 1 2.29000000000001e-06 1 2.29005000000001e-06 0 2.29200000000001e-06 0 2.29205000000001e-06 0 2.29500000000001e-06 0 2.29510000000001e-06 1 2.29600000000001e-06 1 2.29605000000001e-06 0 2.29800000000001e-06 0 2.29805000000001e-06 0 2.30100000000001e-06 0 2.30110000000001e-06 1 2.30200000000001e-06 1 2.30205000000001e-06 0 2.30400000000001e-06 0 2.30405000000001e-06 0 2.30700000000001e-06 0 2.30710000000001e-06 1 2.30800000000001e-06 1 2.30805000000001e-06 0 2.31000000000001e-06 0 2.31005000000001e-06 0 2.31300000000001e-06 0 2.31310000000001e-06 1 2.31400000000001e-06 1 2.31405000000001e-06 0 2.31600000000001e-06 0 2.31605000000001e-06 0 2.31900000000001e-06 0 2.31910000000001e-06 1 2.32000000000001e-06 1 2.32005000000001e-06 0 2.32200000000001e-06 0 2.32205000000001e-06 0 2.32500000000001e-06 0 2.32510000000001e-06 1 2.32600000000001e-06 1 2.32605000000001e-06 0 2.32800000000001e-06 0 2.32805000000001e-06 0 2.33100000000001e-06 0 2.33110000000001e-06 1 2.33200000000001e-06 1 2.33205000000001e-06 0 2.33400000000001e-06 0 2.33405000000001e-06 0 2.33700000000001e-06 0 2.33710000000001e-06 1 2.33800000000001e-06 1 2.33805000000001e-06 0 2.34000000000001e-06 0 2.34005000000001e-06 0 2.34300000000001e-06 0 2.34310000000001e-06 1 2.34400000000001e-06 1 2.34405000000001e-06 0 2.34600000000001e-06 0 2.34605000000001e-06 0 2.34900000000001e-06 0 2.34910000000001e-06 1 2.35000000000001e-06 1 2.35005000000001e-06 0 2.35200000000001e-06 0 2.35205000000001e-06 0 2.35500000000001e-06 0 2.35510000000001e-06 1 2.35600000000001e-06 1 2.35605000000001e-06 0 2.35800000000001e-06 0 2.35805000000001e-06 0 2.36100000000001e-06 0 2.36110000000001e-06 1 2.36200000000001e-06 1 2.36205000000001e-06 0 2.36400000000001e-06 0 2.36405000000001e-06 0 2.36700000000001e-06 0 2.36710000000001e-06 1 2.36800000000001e-06 1 2.36805000000001e-06 0 2.37000000000001e-06 0 2.37005000000001e-06 0 2.37300000000001e-06 0 2.37310000000001e-06 1 2.37400000000001e-06 1 2.37405000000001e-06 0 2.37600000000001e-06 0 2.37605000000001e-06 0 2.37900000000001e-06 0 2.37910000000001e-06 1 2.38000000000001e-06 1 2.38005000000001e-06 0 2.38200000000001e-06 0 2.38205000000001e-06 0 2.38500000000001e-06 0 2.38510000000001e-06 1 2.38600000000001e-06 1 2.38605000000001e-06 0 2.38800000000001e-06 0 2.38805000000001e-06 0 2.39100000000001e-06 0 2.39110000000001e-06 1 2.39200000000001e-06 1 2.39205000000001e-06 0 2.39400000000001e-06 0 2.39405000000001e-06 0 2.39700000000001e-06 0 2.39710000000001e-06 1 2.39800000000001e-06 1 2.39805000000001e-06 0 2.40000000000001e-06 0 2.40005000000001e-06 0 2.40300000000001e-06 0 2.40310000000001e-06 1 2.40400000000001e-06 1 2.40405000000001e-06 0 2.40600000000001e-06 0 2.40605000000001e-06 0 2.40900000000001e-06 0 2.40910000000001e-06 1 2.41000000000001e-06 1 2.41005000000001e-06 0 2.41200000000001e-06 0 2.41205000000001e-06 0 2.41500000000001e-06 0 2.41510000000001e-06 1 2.41600000000001e-06 1 2.41605000000001e-06 0 2.41800000000001e-06 0 2.41805000000001e-06 0 2.42100000000001e-06 0 2.42110000000001e-06 1 2.42200000000001e-06 1 2.42205000000001e-06 0 2.42400000000001e-06 0 2.42405000000001e-06 0 2.42700000000001e-06 0 2.42710000000001e-06 1 2.42800000000001e-06 1 2.42805000000001e-06 0 2.43000000000001e-06 0 2.43005000000001e-06 0 2.43300000000001e-06 0 2.43310000000001e-06 1 2.43400000000001e-06 1 2.43405000000001e-06 0 2.43600000000001e-06 0 2.43605000000001e-06 0 2.43900000000001e-06 0 2.43910000000001e-06 1 2.44000000000001e-06 1 2.44005000000001e-06 0 2.44200000000001e-06 0 2.44205000000001e-06 0 2.44500000000001e-06 0 2.44510000000001e-06 1 2.44600000000001e-06 1 2.44605000000001e-06 0 2.44800000000001e-06 0 2.44805000000001e-06 0 2.45100000000001e-06 0 2.45110000000001e-06 1 2.45200000000001e-06 1 2.45205000000001e-06 0 2.45400000000001e-06 0 2.45405000000001e-06 0 2.45700000000001e-06 0 2.45710000000001e-06 1 2.45800000000001e-06 1 2.45805000000001e-06 0 2.46000000000001e-06 0 2.46005000000001e-06 0 2.46300000000001e-06 0 2.46310000000001e-06 1 2.46400000000001e-06 1 2.46405000000001e-06 0 2.46600000000001e-06 0 2.46605000000001e-06 0 2.46900000000001e-06 0 2.46910000000001e-06 1 2.47000000000001e-06 1 2.47005000000001e-06 0 2.47200000000001e-06 0 2.47205000000001e-06 0 2.47500000000001e-06 0 2.47510000000001e-06 1 2.47600000000001e-06 1 2.47605000000001e-06 0 2.47800000000001e-06 0 2.47805000000001e-06 0 2.48100000000001e-06 0 2.48110000000001e-06 1 2.48200000000001e-06 1 2.48205000000001e-06 0 2.48400000000001e-06 0 2.48405000000001e-06 0 2.48700000000001e-06 0 2.48710000000001e-06 1 2.48800000000001e-06 1 2.48805000000001e-06 0 2.49000000000001e-06 0 2.49005000000001e-06 0 2.49300000000001e-06 0 2.49310000000001e-06 1 2.49400000000001e-06 1 2.49405000000001e-06 0 2.49600000000001e-06 0 2.49605000000001e-06 0 2.49900000000001e-06 0 2.49910000000001e-06 1 2.50000000000001e-06 1 2.50005000000001e-06 0 2.50200000000001e-06 0 2.50205000000001e-06 0 2.50500000000001e-06 0 2.50510000000001e-06 1 2.50600000000001e-06 1 2.50605000000001e-06 0 2.50800000000001e-06 0 2.50805000000001e-06 0 2.51100000000001e-06 0 2.51110000000001e-06 1 2.51200000000001e-06 1 2.51205000000001e-06 0 2.51400000000001e-06 0 2.51405000000001e-06 0 2.51700000000001e-06 0 2.51710000000001e-06 1 2.51800000000001e-06 1 2.51805000000001e-06 0 2.52000000000001e-06 0 2.52005000000001e-06 0 2.52300000000001e-06 0 2.52310000000001e-06 1 2.52400000000001e-06 1 2.52405000000001e-06 0 2.52600000000001e-06 0 2.52605000000001e-06 0 2.52900000000001e-06 0 2.52910000000001e-06 1 2.53000000000001e-06 1 2.53005000000001e-06 0 2.53200000000001e-06 0 2.53205000000001e-06 0 2.53500000000001e-06 0 2.53510000000001e-06 1 2.53600000000001e-06 1 2.53605000000001e-06 0 2.53800000000001e-06 0 2.53805000000001e-06 0 2.54100000000001e-06 0 2.54110000000001e-06 1 2.54200000000001e-06 1 2.54205000000001e-06 0 2.54400000000001e-06 0 2.54405000000001e-06 0 2.54700000000001e-06 0 2.54710000000001e-06 1 2.54800000000001e-06 1 2.54805000000001e-06 0 2.55000000000001e-06 0 2.55005000000001e-06 0 2.55300000000001e-06 0 2.55310000000001e-06 1 2.55400000000001e-06 1 2.55405000000001e-06 0 2.55600000000001e-06 0 2.55605000000001e-06 0 2.55900000000001e-06 0 2.55910000000001e-06 1 2.56000000000001e-06 1 2.56005000000001e-06 0 2.56200000000001e-06 0 2.56205000000001e-06 0 2.56500000000001e-06 0 2.56510000000001e-06 1 2.56600000000001e-06 1 2.56605000000001e-06 0 2.56800000000001e-06 0 2.56805000000001e-06 0 2.57100000000001e-06 0 2.57110000000001e-06 1 2.57200000000001e-06 1 2.57205000000001e-06 0 2.57400000000001e-06 0 2.57405000000001e-06 0 2.57700000000001e-06 0 2.57710000000001e-06 1 2.57800000000001e-06 1 2.57805000000001e-06 0 2.58000000000001e-06 0 2.58005000000001e-06 0 2.58300000000001e-06 0 2.58310000000001e-06 1 2.58400000000001e-06 1 2.58405000000001e-06 0 2.58600000000001e-06 0 2.58605000000001e-06 0 2.58900000000001e-06 0 2.58910000000001e-06 1 2.59000000000001e-06 1 2.59005000000001e-06 0 2.59200000000001e-06 0 2.59205000000001e-06 0 2.59500000000001e-06 0 2.59510000000001e-06 1 2.59600000000001e-06 1 2.59605000000001e-06 0 2.59800000000001e-06 0 2.59805000000001e-06 0 2.60100000000001e-06 0 2.60110000000001e-06 1 2.60200000000001e-06 1 2.60205000000001e-06 0 2.60400000000001e-06 0 2.60405000000001e-06 0 2.60700000000001e-06 0 2.60710000000001e-06 1 2.60800000000001e-06 1 2.60805000000001e-06 0 2.61000000000001e-06 0 2.61005000000001e-06 0 2.61300000000001e-06 0 2.61310000000001e-06 1 2.61400000000001e-06 1 2.61405000000001e-06 0 2.61600000000001e-06 0 2.61605000000001e-06 0 2.61900000000001e-06 0 2.61910000000001e-06 1 2.62000000000001e-06 1 2.62005000000001e-06 0 2.62200000000001e-06 0 2.62205000000001e-06 0 2.62500000000001e-06 0 2.62510000000001e-06 1 2.62600000000001e-06 1 2.62605000000001e-06 0 2.62800000000001e-06 0 2.62805000000001e-06 0 2.63100000000001e-06 0 2.63110000000001e-06 1 2.63200000000001e-06 1 2.63205000000001e-06 0 2.63400000000001e-06 0 2.63405000000001e-06 0 2.63700000000001e-06 0 2.63710000000001e-06 1 2.63800000000001e-06 1 2.63805000000001e-06 0 2.64000000000001e-06 0 2.64005000000001e-06 0 2.64300000000001e-06 0 2.64310000000001e-06 1 2.64400000000001e-06 1 2.64405000000001e-06 0 2.64600000000001e-06 0 2.64605000000001e-06 0 2.64900000000001e-06 0 2.64910000000001e-06 1 2.65000000000001e-06 1 2.65005000000001e-06 0 2.65200000000001e-06 0 2.65205000000001e-06 0 2.65500000000001e-06 0 2.65510000000001e-06 1 2.65600000000001e-06 1 2.65605000000001e-06 0 2.65800000000001e-06 0 2.65805000000001e-06 0 2.66100000000001e-06 0 2.66110000000001e-06 1 2.66200000000001e-06 1 2.66205000000001e-06 0 2.66400000000001e-06 0 2.66405000000001e-06 0 2.66700000000001e-06 0 2.66710000000001e-06 1 2.66800000000001e-06 1 2.66805000000001e-06 0 2.67000000000001e-06 0 2.67005000000001e-06 0 2.67300000000001e-06 0 2.67310000000001e-06 1 2.67400000000001e-06 1 2.67405000000001e-06 0 2.67600000000001e-06 0 2.67605000000001e-06 0 2.67900000000001e-06 0 2.67910000000001e-06 1 2.68000000000001e-06 1 2.68005000000001e-06 0 2.68200000000001e-06 0 2.68205000000001e-06 0 2.68500000000001e-06 0 2.68510000000001e-06 1 2.68600000000001e-06 1 2.68605000000001e-06 0 2.68800000000001e-06 0 2.68805000000001e-06 0 2.69100000000001e-06 0 2.69110000000001e-06 1 2.69200000000001e-06 1 2.69205000000001e-06 0 2.69400000000001e-06 0 2.69405000000001e-06 0 2.69700000000001e-06 0 2.69710000000001e-06 1 2.69800000000001e-06 1 2.69805000000001e-06 0 2.70000000000001e-06 0 2.70005000000001e-06 0 2.70300000000001e-06 0 2.70310000000001e-06 1 2.70400000000001e-06 1 2.70405000000001e-06 0 2.70600000000001e-06 0 2.70605000000001e-06 0 2.70900000000001e-06 0 2.70910000000001e-06 1 2.71000000000001e-06 1 2.71005000000001e-06 0 2.71200000000001e-06 0 2.71205000000001e-06 0 2.71500000000001e-06 0 2.71510000000001e-06 1 2.71600000000001e-06 1 2.71605000000001e-06 0 2.71800000000001e-06 0 2.71805000000001e-06 0 2.72100000000001e-06 0 2.72110000000001e-06 1 2.72200000000001e-06 1 2.72205000000001e-06 0 2.72400000000001e-06 0 2.72405000000001e-06 0 2.72700000000001e-06 0 2.72710000000001e-06 1 2.72800000000001e-06 1 2.72805000000001e-06 0 2.73000000000001e-06 0 2.73005000000001e-06 0 2.73300000000001e-06 0 2.73310000000001e-06 1 2.73400000000001e-06 1 2.73405000000001e-06 0 2.73600000000001e-06 0 2.73605000000001e-06 0 2.73900000000001e-06 0 2.73910000000001e-06 1 2.74000000000001e-06 1 2.74005000000001e-06 0 2.74200000000001e-06 0 2.74205000000001e-06 0 2.74500000000001e-06 0 2.74510000000001e-06 1 2.74600000000001e-06 1 2.74605000000001e-06 0 2.74800000000001e-06 0 2.74805000000001e-06 0 2.75100000000001e-06 0 2.75110000000001e-06 1 2.75200000000001e-06 1 2.75205000000001e-06 0 2.75400000000001e-06 0 2.75405000000001e-06 0 2.75700000000001e-06 0 2.75710000000001e-06 1 2.75800000000001e-06 1 2.75805000000001e-06 0 2.76000000000001e-06 0 2.76005000000001e-06 0 2.76300000000001e-06 0 2.76310000000001e-06 1 2.76400000000001e-06 1 2.76405000000001e-06 0 2.76600000000001e-06 0 2.76605000000001e-06 0 2.76900000000001e-06 0 2.76910000000001e-06 1 2.77000000000001e-06 1 2.77005000000001e-06 0 2.77200000000001e-06 0 2.77205000000001e-06 0 2.77500000000001e-06 0 2.77510000000001e-06 1 2.77600000000001e-06 1 2.77605000000001e-06 0 2.77800000000001e-06 0 2.77805000000001e-06 0 2.78100000000001e-06 0 2.78110000000001e-06 1 2.78200000000001e-06 1 2.78205000000001e-06 0 2.78400000000001e-06 0 2.78405000000001e-06 0 2.78700000000001e-06 0 2.78710000000001e-06 1 2.78800000000001e-06 1 2.78805000000001e-06 0 2.79000000000001e-06 0 2.79005000000001e-06 0 2.79300000000001e-06 0 2.79310000000001e-06 1 2.79400000000001e-06 1 2.79405000000001e-06 0 2.79600000000001e-06 0 2.79605000000001e-06 0 2.79900000000001e-06 0 2.79910000000001e-06 1 2.80000000000001e-06 1 2.80005000000001e-06 0 2.80200000000001e-06 0 2.80205000000001e-06 0 2.80500000000001e-06 0 2.80510000000001e-06 1 2.80600000000001e-06 1 2.80605000000001e-06 0 2.80800000000001e-06 0 2.80805000000001e-06 0 2.81100000000001e-06 0 2.81110000000001e-06 1 2.81200000000001e-06 1 2.81205000000001e-06 0 2.81400000000001e-06 0 2.81405000000001e-06 0 2.81700000000001e-06 0 2.81710000000001e-06 1 2.81800000000001e-06 1 2.81805000000001e-06 0 2.82000000000001e-06 0 2.82005000000001e-06 0 2.82300000000001e-06 0 2.82310000000001e-06 1 2.82400000000001e-06 1 2.82405000000001e-06 0 2.82600000000001e-06 0 2.82605000000001e-06 0 2.82900000000001e-06 0 2.82910000000001e-06 1 2.83000000000001e-06 1 2.83005000000001e-06 0 2.83200000000001e-06 0 2.83205000000001e-06 0 2.83500000000001e-06 0 2.83510000000001e-06 1 2.83600000000001e-06 1 2.83605000000001e-06 0 2.83800000000001e-06 0 2.83805000000001e-06 0 2.84100000000001e-06 0 2.84110000000001e-06 1 2.84200000000001e-06 1 2.84205000000001e-06 0 2.84400000000001e-06 0 2.84405000000001e-06 0 2.84700000000001e-06 0 2.84710000000001e-06 1 2.84800000000001e-06 1 2.84805000000001e-06 0 2.85000000000001e-06 0 2.85005000000001e-06 0 2.85300000000001e-06 0 2.85310000000001e-06 1 2.85400000000001e-06 1 2.85405000000001e-06 0 2.85600000000001e-06 0 2.85605000000001e-06 0 2.85900000000001e-06 0 2.85910000000001e-06 1 2.86000000000001e-06 1 2.86005000000001e-06 0 2.86200000000001e-06 0 2.86205000000001e-06 0 2.86500000000001e-06 0 2.86510000000001e-06 1 2.86600000000001e-06 1 2.86605000000001e-06 0 2.86800000000001e-06 0 2.86805000000001e-06 0 2.87100000000001e-06 0 2.87110000000001e-06 1 2.87200000000001e-06 1 2.87205000000001e-06 0 2.87400000000001e-06 0 2.87405000000001e-06 0 2.87700000000001e-06 0 2.87710000000001e-06 1 2.87800000000001e-06 1 2.87805000000001e-06 0 2.88000000000001e-06 0 2.88005000000001e-06 0 2.88300000000001e-06 0 2.88310000000001e-06 1 2.88400000000001e-06 1 2.88405000000001e-06 0 2.88600000000001e-06 0 2.88605000000001e-06 0 2.88900000000001e-06 0 2.88910000000001e-06 1 2.89000000000001e-06 1 2.89005000000001e-06 0 2.89200000000001e-06 0 2.89205000000001e-06 0 2.89500000000001e-06 0 2.89510000000001e-06 1 2.89600000000001e-06 1 2.89605000000001e-06 0 2.89800000000001e-06 0 2.89805000000001e-06 0 2.90100000000001e-06 0 2.90110000000001e-06 1 2.90200000000001e-06 1 2.90205000000001e-06 0 2.90400000000001e-06 0 2.90405000000001e-06 0 2.90700000000001e-06 0 2.90710000000001e-06 1 2.90800000000001e-06 1 2.90805000000001e-06 0 2.91000000000001e-06 0 2.91005000000001e-06 0 2.91300000000001e-06 0 2.91310000000001e-06 1 2.91400000000001e-06 1 2.91405000000001e-06 0 2.91600000000001e-06 0 2.91605000000001e-06 0 2.91900000000001e-06 0 2.91910000000001e-06 1 2.92000000000001e-06 1 2.92005000000001e-06 0 2.92200000000001e-06 0 2.92205000000001e-06 0 2.92500000000001e-06 0 2.92510000000001e-06 1 2.92600000000001e-06 1 2.92605000000001e-06 0 2.92800000000001e-06 0 2.92805000000001e-06 0 2.93100000000001e-06 0 2.93110000000001e-06 1 2.93200000000001e-06 1 2.93205000000001e-06 0 2.93400000000001e-06 0 2.93405000000001e-06 0 2.93700000000001e-06 0 2.93710000000001e-06 1 2.93800000000001e-06 1 2.93805000000001e-06 0 2.94000000000001e-06 0 2.94005000000001e-06 0 2.94300000000001e-06 0 2.94310000000001e-06 1 2.94400000000001e-06 1 2.94405000000001e-06 0 2.94600000000001e-06 0 2.94605000000001e-06 0 2.94900000000001e-06 0 2.94910000000001e-06 1 2.95000000000001e-06 1 2.95005000000001e-06 0 2.95200000000001e-06 0 2.95205000000001e-06 0 2.95500000000001e-06 0 2.95510000000001e-06 1 2.95600000000001e-06 1 2.95605000000001e-06 0 2.95800000000001e-06 0 2.95805000000001e-06 0 2.96100000000001e-06 0 2.96110000000001e-06 1 2.96200000000001e-06 1 2.96205000000001e-06 0 2.96400000000001e-06 0 2.96405000000001e-06 0 2.96700000000001e-06 0 2.96710000000001e-06 1 2.96800000000001e-06 1 2.96805000000001e-06 0 2.97000000000001e-06 0 2.97005000000001e-06 0 2.97300000000001e-06 0 2.97310000000001e-06 1 2.97400000000001e-06 1 2.97405000000001e-06 0 2.97600000000001e-06 0 2.97605000000001e-06 0 2.97900000000001e-06 0 2.97910000000001e-06 1 2.98000000000001e-06 1 2.98005000000001e-06 0 2.98200000000001e-06 0 2.98205000000001e-06 0 2.98500000000001e-06 0 2.98510000000001e-06 1 2.98600000000001e-06 1 2.98605000000001e-06 0 2.98800000000001e-06 0 2.98805000000001e-06 0 2.99100000000001e-06 0 2.99110000000001e-06 1 2.99200000000001e-06 1 2.99205000000001e-06 0 2.99400000000001e-06 0 2.99405000000001e-06 0 2.99700000000001e-06 0 2.99710000000001e-06 1 2.99800000000001e-06 1 2.99805000000001e-06 0 3.00000000000001e-06 0 3.00005000000001e-06 0 3.00300000000001e-06 0 3.00310000000001e-06 1 3.00400000000001e-06 1 3.00405000000001e-06 0 3.00600000000001e-06 0 3.00605000000001e-06 0 3.00900000000001e-06 0 3.00910000000001e-06 1 3.01000000000001e-06 1 3.01005000000001e-06 0 3.01200000000001e-06 0 3.01205000000001e-06 0 3.01500000000001e-06 0 3.01510000000001e-06 1 3.01600000000001e-06 1 3.01605000000001e-06 0 3.01800000000001e-06 0 3.01805000000001e-06 0 3.02100000000001e-06 0 3.02110000000001e-06 1 3.02200000000001e-06 1 3.02205000000001e-06 0 3.02400000000001e-06 0 3.02405000000001e-06 0 3.02700000000001e-06 0 3.02710000000001e-06 1 3.02800000000001e-06 1 3.02805000000001e-06 0 3.03000000000001e-06 0 3.03005000000001e-06 0 3.03300000000001e-06 0 3.03310000000001e-06 1 3.03400000000001e-06 1 3.03405000000001e-06 0 3.03600000000001e-06 0 3.03605000000001e-06 0 3.03900000000001e-06 0 3.03910000000001e-06 1 3.04000000000001e-06 1 3.04005000000001e-06 0 3.04200000000001e-06 0 3.04205000000001e-06 0 3.04500000000001e-06 0 3.04510000000001e-06 1 3.04600000000001e-06 1 3.04605000000001e-06 0 3.04800000000001e-06 0 3.04805000000001e-06 0 3.05100000000001e-06 0 3.05110000000001e-06 1 3.05200000000001e-06 1 3.05205000000001e-06 0 3.05400000000001e-06 0 3.05405000000001e-06 0 3.05700000000001e-06 0 3.05710000000001e-06 1 3.05800000000001e-06 1 3.05805000000001e-06 0 3.06000000000001e-06 0 3.06005000000001e-06 0 3.06300000000001e-06 0 3.06310000000001e-06 1 3.06400000000001e-06 1 3.06405000000001e-06 0 3.06600000000001e-06 0 3.06605000000001e-06 0 3.06900000000001e-06 0 3.06910000000001e-06 1 3.07000000000001e-06 1 3.07005000000001e-06 0 3.07550000000001e-06 0]
parameters wave_SAN = [0 0 4e-09 0 4.1e-09 1 5.5e-09 1 5.55e-09 0 6e-09 0 6.05e-09 0 1e-08 0 1.01e-08 1 1.15e-08 1 1.155e-08 0 1.2e-08 0 1.205e-08 0 1.6e-08 0 1.61e-08 1 1.75e-08 1 1.755e-08 0 1.8e-08 0 1.805e-08 0 2.2e-08 0 2.21e-08 1 2.35e-08 1 2.355e-08 0 2.4e-08 0 2.405e-08 0 2.8e-08 0 2.81e-08 1 2.95e-08 1 2.955e-08 0 3e-08 0 3.005e-08 0 3.4e-08 0 3.41e-08 1 3.55e-08 1 3.555e-08 0 3.6e-08 0 3.605e-08 0 4e-08 0 4.01e-08 1 4.15e-08 1 4.155e-08 0 4.2e-08 0 4.205e-08 0 4.6e-08 0 4.61e-08 1 4.75e-08 1 4.755e-08 0 4.8e-08 0 4.805e-08 0 5.2e-08 0 5.21e-08 1 5.35e-08 1 5.355e-08 0 5.4e-08 0 5.405e-08 0 5.8e-08 0 5.81e-08 1 5.95e-08 1 5.955e-08 0 6e-08 0 6.005e-08 0 6.4e-08 0 6.41e-08 1 6.55e-08 1 6.555e-08 0 6.6e-08 0 6.605e-08 0 7e-08 0 7.01e-08 1 7.15e-08 1 7.155e-08 0 7.2e-08 0 7.205e-08 0 7.6e-08 0 7.61e-08 1 7.75e-08 1 7.755e-08 0 7.8e-08 0 7.805e-08 0 8.2e-08 0 8.21e-08 1 8.35e-08 1 8.355e-08 0 8.4e-08 0 8.405e-08 0 8.8e-08 0 8.81e-08 1 8.95e-08 1 8.955e-08 0 9e-08 0 9.005e-08 0 9.4e-08 0 9.41e-08 1 9.55e-08 1 9.555e-08 0 9.6e-08 0 9.605e-08 0 1e-07 0 1.001e-07 1 1.015e-07 1 1.0155e-07 0 1.02e-07 0 1.0205e-07 0 1.06e-07 0 1.061e-07 1 1.075e-07 1 1.0755e-07 0 1.08e-07 0 1.0805e-07 0 1.12e-07 0 1.121e-07 1 1.135e-07 1 1.1355e-07 0 1.14e-07 0 1.1405e-07 0 1.18e-07 0 1.181e-07 1 1.195e-07 1 1.1955e-07 0 1.2e-07 0 1.2005e-07 0 1.24e-07 0 1.241e-07 1 1.255e-07 1 1.2555e-07 0 1.26e-07 0 1.2605e-07 0 1.3e-07 0 1.301e-07 1 1.315e-07 1 1.3155e-07 0 1.32e-07 0 1.3205e-07 0 1.36e-07 0 1.361e-07 1 1.375e-07 1 1.3755e-07 0 1.38e-07 0 1.3805e-07 0 1.42e-07 0 1.421e-07 1 1.435e-07 1 1.4355e-07 0 1.44e-07 0 1.4405e-07 0 1.48e-07 0 1.481e-07 1 1.495e-07 1 1.4955e-07 0 1.5e-07 0 1.5005e-07 0 1.54e-07 0 1.541e-07 1 1.555e-07 1 1.5555e-07 0 1.56e-07 0 1.5605e-07 0 1.6e-07 0 1.601e-07 1 1.615e-07 1 1.6155e-07 0 1.62e-07 0 1.6205e-07 0 1.66e-07 0 1.661e-07 1 1.675e-07 1 1.6755e-07 0 1.68e-07 0 1.6805e-07 0 1.72e-07 0 1.721e-07 1 1.735e-07 1 1.7355e-07 0 1.74e-07 0 1.7405e-07 0 1.78e-07 0 1.781e-07 1 1.795e-07 1 1.7955e-07 0 1.8e-07 0 1.8005e-07 0 1.84e-07 0 1.841e-07 1 1.855e-07 1 1.8555e-07 0 1.86e-07 0 1.8605e-07 0 1.9e-07 0 1.901e-07 1 1.915e-07 1 1.9155e-07 0 1.92e-07 0 1.9205e-07 0 1.96e-07 0 1.961e-07 1 1.975e-07 1 1.9755e-07 0 1.98e-07 0 1.9805e-07 0 2.02e-07 0 2.021e-07 1 2.035e-07 1 2.0355e-07 0 2.04e-07 0 2.0405e-07 0 2.08e-07 0 2.081e-07 1 2.095e-07 1 2.0955e-07 0 2.1e-07 0 2.1005e-07 0 2.14e-07 0 2.141e-07 1 2.155e-07 1 2.1555e-07 0 2.16e-07 0 2.1605e-07 0 2.2e-07 0 2.201e-07 1 2.215e-07 1 2.2155e-07 0 2.22e-07 0 2.2205e-07 0 2.26e-07 0 2.261e-07 1 2.275e-07 1 2.2755e-07 0 2.28000000000001e-07 0 2.28050000000001e-07 0 2.32000000000001e-07 0 2.32100000000001e-07 1 2.33500000000001e-07 1 2.33550000000001e-07 0 2.34000000000001e-07 0 2.34050000000001e-07 0 2.38000000000001e-07 0 2.38100000000001e-07 1 2.39500000000001e-07 1 2.39550000000001e-07 0 2.40000000000001e-07 0 2.40050000000001e-07 0 2.44e-07 0 2.441e-07 1 2.455e-07 1 2.45550000000001e-07 0 2.46e-07 0 2.4605e-07 0 2.5e-07 0 2.501e-07 1 2.515e-07 1 2.5155e-07 0 2.52e-07 0 2.5205e-07 0 2.56e-07 0 2.561e-07 1 2.575e-07 1 2.5755e-07 0 2.58e-07 0 2.5805e-07 0 2.62e-07 0 2.621e-07 1 2.635e-07 1 2.6355e-07 0 2.64e-07 0 2.6405e-07 0 2.68e-07 0 2.681e-07 1 2.695e-07 1 2.6955e-07 0 2.7e-07 0 2.7005e-07 0 2.74e-07 0 2.741e-07 1 2.755e-07 1 2.7555e-07 0 2.76e-07 0 2.7605e-07 0 2.8e-07 0 2.801e-07 1 2.815e-07 1 2.8155e-07 0 2.82e-07 0 2.8205e-07 0 2.86e-07 0 2.861e-07 1 2.875e-07 1 2.8755e-07 0 2.88e-07 0 2.8805e-07 0 2.92e-07 0 2.921e-07 1 2.935e-07 1 2.9355e-07 0 2.94e-07 0 2.9405e-07 0 2.98e-07 0 2.981e-07 1 2.995e-07 1 2.9955e-07 0 3e-07 0 3.0005e-07 0 3.04e-07 0 3.041e-07 1 3.055e-07 1 3.0555e-07 0 3.06e-07 0 3.0605e-07 0 3.1e-07 0 3.101e-07 1 3.115e-07 1 3.1155e-07 0 3.12e-07 0 3.1205e-07 0 3.16e-07 0 3.161e-07 1 3.175e-07 1 3.1755e-07 0 3.18e-07 0 3.1805e-07 0 3.22e-07 0 3.221e-07 1 3.235e-07 1 3.2355e-07 0 3.24e-07 0 3.2405e-07 0 3.28e-07 0 3.281e-07 1 3.295e-07 1 3.2955e-07 0 3.3e-07 0 3.3005e-07 0 3.34e-07 0 3.341e-07 1 3.355e-07 1 3.3555e-07 0 3.36e-07 0 3.3605e-07 0 3.4e-07 0 3.401e-07 1 3.415e-07 1 3.4155e-07 0 3.42e-07 0 3.4205e-07 0 3.46e-07 0 3.461e-07 1 3.475e-07 1 3.4755e-07 0 3.48e-07 0 3.4805e-07 0 3.52e-07 0 3.521e-07 1 3.535e-07 1 3.5355e-07 0 3.54e-07 0 3.5405e-07 0 3.58e-07 0 3.581e-07 1 3.595e-07 1 3.5955e-07 0 3.6e-07 0 3.6005e-07 0 3.64e-07 0 3.641e-07 1 3.655e-07 1 3.6555e-07 0 3.66e-07 0 3.6605e-07 0 3.7e-07 0 3.701e-07 1 3.715e-07 1 3.7155e-07 0 3.72e-07 0 3.7205e-07 0 3.76e-07 0 3.761e-07 1 3.775e-07 1 3.7755e-07 0 3.78e-07 0 3.7805e-07 0 3.82e-07 0 3.821e-07 1 3.835e-07 1 3.8355e-07 0 3.84e-07 0 3.8405e-07 0 3.88e-07 0 3.881e-07 1 3.895e-07 1 3.8955e-07 0 3.9e-07 0 3.9005e-07 0 3.94e-07 0 3.941e-07 1 3.955e-07 1 3.9555e-07 0 3.96e-07 0 3.9605e-07 0 4e-07 0 4.001e-07 1 4.015e-07 1 4.0155e-07 0 4.02e-07 0 4.0205e-07 0 4.06e-07 0 4.061e-07 1 4.075e-07 1 4.0755e-07 0 4.08e-07 0 4.0805e-07 0 4.12e-07 0 4.121e-07 1 4.135e-07 1 4.1355e-07 0 4.14e-07 0 4.1405e-07 0 4.18e-07 0 4.181e-07 1 4.195e-07 1 4.1955e-07 0 4.2e-07 0 4.2005e-07 0 4.24e-07 0 4.241e-07 1 4.255e-07 1 4.2555e-07 0 4.26e-07 0 4.2605e-07 0 4.3e-07 0 4.301e-07 1 4.315e-07 1 4.3155e-07 0 4.32e-07 0 4.3205e-07 0 4.36e-07 0 4.361e-07 1 4.375e-07 1 4.3755e-07 0 4.38e-07 0 4.3805e-07 0 4.42e-07 0 4.421e-07 1 4.435e-07 1 4.4355e-07 0 4.44e-07 0 4.4405e-07 0 4.48e-07 0 4.481e-07 1 4.495e-07 1 4.4955e-07 0 4.5e-07 0 4.5005e-07 0 4.54e-07 0 4.541e-07 1 4.555e-07 1 4.5555e-07 0 4.56e-07 0 4.5605e-07 0 4.6e-07 0 4.601e-07 1 4.615e-07 1 4.6155e-07 0 4.62e-07 0 4.6205e-07 0 4.66e-07 0 4.661e-07 1 4.675e-07 1 4.6755e-07 0 4.68e-07 0 4.6805e-07 0 4.72e-07 0 4.721e-07 1 4.735e-07 1 4.7355e-07 0 4.74e-07 0 4.7405e-07 0 4.77999999999999e-07 0 4.78099999999999e-07 1 4.79499999999999e-07 1 4.79549999999999e-07 0 4.8e-07 0 4.8005e-07 0 4.84e-07 0 4.841e-07 1 4.855e-07 1 4.8555e-07 0 4.86e-07 0 4.8605e-07 0 4.9e-07 0 4.901e-07 1 4.915e-07 1 4.9155e-07 0 4.92e-07 0 4.9205e-07 0 4.96e-07 0 4.961e-07 1 4.975e-07 1 4.9755e-07 0 4.98e-07 0 4.9805e-07 0 5.02e-07 0 5.021e-07 1 5.035e-07 1 5.0355e-07 0 5.04e-07 0 5.0405e-07 0 5.08e-07 0 5.081e-07 1 5.095e-07 1 5.0955e-07 0 5.1e-07 0 5.1005e-07 0 5.14e-07 0 5.141e-07 1 5.155e-07 1 5.1555e-07 0 5.16e-07 0 5.1605e-07 0 5.2e-07 0 5.201e-07 1 5.215e-07 1 5.2155e-07 0 5.22e-07 0 5.2205e-07 0 5.26e-07 0 5.261e-07 1 5.275e-07 1 5.2755e-07 0 5.28e-07 0 5.2805e-07 0 5.32e-07 0 5.321e-07 1 5.335e-07 1 5.3355e-07 0 5.34e-07 0 5.3405e-07 0 5.38e-07 0 5.381e-07 1 5.395e-07 1 5.3955e-07 0 5.4e-07 0 5.4005e-07 0 5.44e-07 0 5.441e-07 1 5.455e-07 1 5.4555e-07 0 5.46e-07 0 5.4605e-07 0 5.5e-07 0 5.501e-07 1 5.515e-07 1 5.5155e-07 0 5.52e-07 0 5.5205e-07 0 5.56e-07 0 5.561e-07 1 5.575e-07 1 5.5755e-07 0 5.58e-07 0 5.5805e-07 0 5.62e-07 0 5.621e-07 1 5.635e-07 1 5.6355e-07 0 5.64e-07 0 5.6405e-07 0 5.68e-07 0 5.681e-07 1 5.695e-07 1 5.6955e-07 0 5.7e-07 0 5.7005e-07 0 5.74e-07 0 5.741e-07 1 5.755e-07 1 5.7555e-07 0 5.76e-07 0 5.7605e-07 0 5.8e-07 0 5.801e-07 1 5.815e-07 1 5.8155e-07 0 5.82e-07 0 5.8205e-07 0 5.86e-07 0 5.861e-07 1 5.875e-07 1 5.8755e-07 0 5.88e-07 0 5.8805e-07 0 5.92e-07 0 5.921e-07 1 5.935e-07 1 5.9355e-07 0 5.94e-07 0 5.9405e-07 0 5.98e-07 0 5.981e-07 1 5.995e-07 1 5.9955e-07 0 6e-07 0 6.0005e-07 0 6.04e-07 0 6.041e-07 1 6.055e-07 1 6.0555e-07 0 6.06e-07 0 6.0605e-07 0 6.1e-07 0 6.101e-07 1 6.115e-07 1 6.1155e-07 0 6.12e-07 0 6.1205e-07 0 6.16e-07 0 6.161e-07 1 6.175e-07 1 6.1755e-07 0 6.18e-07 0 6.1805e-07 0 6.22e-07 0 6.221e-07 1 6.235e-07 1 6.2355e-07 0 6.24e-07 0 6.2405e-07 0 6.28e-07 0 6.281e-07 1 6.295e-07 1 6.2955e-07 0 6.3e-07 0 6.3005e-07 0 6.34e-07 0 6.341e-07 1 6.355e-07 1 6.3555e-07 0 6.36e-07 0 6.3605e-07 0 6.4e-07 0 6.401e-07 1 6.415e-07 1 6.4155e-07 0 6.42e-07 0 6.4205e-07 0 6.46e-07 0 6.461e-07 1 6.475e-07 1 6.4755e-07 0 6.48e-07 0 6.4805e-07 0 6.52e-07 0 6.521e-07 1 6.535e-07 1 6.5355e-07 0 6.54e-07 0 6.5405e-07 0 6.58e-07 0 6.581e-07 1 6.595e-07 1 6.5955e-07 0 6.6e-07 0 6.6005e-07 0 6.64e-07 0 6.641e-07 1 6.655e-07 1 6.6555e-07 0 6.66e-07 0 6.6605e-07 0 6.7e-07 0 6.701e-07 1 6.715e-07 1 6.7155e-07 0 6.72e-07 0 6.7205e-07 0 6.76e-07 0 6.761e-07 1 6.775e-07 1 6.7755e-07 0 6.78e-07 0 6.7805e-07 0 6.82e-07 0 6.821e-07 1 6.835e-07 1 6.8355e-07 0 6.84e-07 0 6.8405e-07 0 6.88e-07 0 6.881e-07 1 6.895e-07 1 6.8955e-07 0 6.9e-07 0 6.9005e-07 0 6.94e-07 0 6.941e-07 1 6.955e-07 1 6.9555e-07 0 6.96000000000001e-07 0 6.96050000000001e-07 0 7e-07 0 7.00100000000001e-07 1 7.01500000000001e-07 1 7.01550000000001e-07 0 7.02000000000001e-07 0 7.02050000000001e-07 0 7.06000000000001e-07 0 7.06100000000001e-07 1 7.07500000000001e-07 1 7.07550000000001e-07 0 7.08000000000001e-07 0 7.08050000000001e-07 0 7.12000000000001e-07 0 7.12100000000001e-07 1 7.13500000000001e-07 1 7.13550000000001e-07 0 7.14000000000001e-07 0 7.14050000000001e-07 0 7.18000000000001e-07 0 7.18100000000001e-07 1 7.19500000000001e-07 1 7.19550000000001e-07 0 7.20000000000001e-07 0 7.20050000000001e-07 0 7.24000000000001e-07 0 7.24100000000001e-07 1 7.25500000000001e-07 1 7.25550000000001e-07 0 7.26000000000001e-07 0 7.26050000000001e-07 0 7.30000000000001e-07 0 7.30100000000001e-07 1 7.31500000000001e-07 1 7.31550000000001e-07 0 7.32000000000001e-07 0 7.32050000000001e-07 0 7.36000000000001e-07 0 7.36100000000001e-07 1 7.37500000000001e-07 1 7.37550000000001e-07 0 7.38000000000001e-07 0 7.38050000000001e-07 0 7.42000000000001e-07 0 7.42100000000001e-07 1 7.43500000000001e-07 1 7.43550000000001e-07 0 7.44000000000001e-07 0 7.44050000000001e-07 0 7.48000000000001e-07 0 7.48100000000001e-07 1 7.49500000000001e-07 1 7.49550000000001e-07 0 7.50000000000001e-07 0 7.50050000000001e-07 0 7.54000000000001e-07 0 7.54100000000001e-07 1 7.55500000000001e-07 1 7.55550000000001e-07 0 7.56000000000001e-07 0 7.56050000000001e-07 0 7.60000000000001e-07 0 7.60100000000001e-07 1 7.61500000000001e-07 1 7.61550000000001e-07 0 7.62000000000001e-07 0 7.62050000000001e-07 0 7.66000000000001e-07 0 7.66100000000001e-07 1 7.67500000000001e-07 1 7.67550000000001e-07 0 7.68000000000001e-07 0 7.68050000000001e-07 0 7.72000000000001e-07 0 7.72100000000001e-07 1 7.73500000000001e-07 1 7.73550000000001e-07 0 7.74000000000001e-07 0 7.74050000000001e-07 0 7.78000000000001e-07 0 7.78100000000001e-07 1 7.79500000000001e-07 1 7.79550000000001e-07 0 7.80000000000001e-07 0 7.80050000000001e-07 0 7.84000000000001e-07 0 7.84100000000001e-07 1 7.85500000000001e-07 1 7.85550000000001e-07 0 7.86000000000001e-07 0 7.86050000000001e-07 0 7.90000000000001e-07 0 7.90100000000001e-07 1 7.91500000000001e-07 1 7.91550000000001e-07 0 7.92000000000001e-07 0 7.92050000000001e-07 0 7.96000000000001e-07 0 7.96100000000001e-07 1 7.97500000000001e-07 1 7.97550000000001e-07 0 7.98000000000001e-07 0 7.98050000000001e-07 0 8.02000000000001e-07 0 8.02100000000001e-07 1 8.03500000000001e-07 1 8.03550000000001e-07 0 8.04000000000001e-07 0 8.04050000000001e-07 0 8.08000000000001e-07 0 8.08100000000001e-07 1 8.09500000000001e-07 1 8.09550000000001e-07 0 8.10000000000001e-07 0 8.10050000000001e-07 0 8.14000000000001e-07 0 8.14100000000001e-07 1 8.15500000000001e-07 1 8.15550000000001e-07 0 8.16000000000001e-07 0 8.16050000000001e-07 0 8.20000000000001e-07 0 8.20100000000001e-07 1 8.21500000000001e-07 1 8.21550000000001e-07 0 8.22000000000001e-07 0 8.22050000000001e-07 0 8.26000000000001e-07 0 8.26100000000001e-07 1 8.27500000000001e-07 1 8.27550000000001e-07 0 8.28000000000001e-07 0 8.28050000000001e-07 0 8.32000000000001e-07 0 8.32100000000001e-07 1 8.33500000000001e-07 1 8.33550000000001e-07 0 8.34000000000001e-07 0 8.34050000000001e-07 0 8.38000000000001e-07 0 8.38100000000001e-07 1 8.39500000000001e-07 1 8.39550000000001e-07 0 8.40000000000001e-07 0 8.40050000000001e-07 0 8.44000000000001e-07 0 8.44100000000001e-07 1 8.45500000000001e-07 1 8.45550000000001e-07 0 8.46000000000001e-07 0 8.46050000000001e-07 0 8.50000000000001e-07 0 8.50100000000001e-07 1 8.51500000000001e-07 1 8.51550000000001e-07 0 8.52000000000001e-07 0 8.52050000000001e-07 0 8.56000000000001e-07 0 8.56100000000001e-07 1 8.57500000000001e-07 1 8.57550000000001e-07 0 8.58000000000001e-07 0 8.58050000000001e-07 0 8.62000000000001e-07 0 8.62100000000001e-07 1 8.63500000000001e-07 1 8.63550000000001e-07 0 8.64000000000001e-07 0 8.64050000000001e-07 0 8.68000000000001e-07 0 8.68100000000001e-07 1 8.69500000000001e-07 1 8.69550000000001e-07 0 8.70000000000001e-07 0 8.70050000000001e-07 0 8.74000000000001e-07 0 8.74100000000001e-07 1 8.75500000000001e-07 1 8.75550000000001e-07 0 8.76000000000001e-07 0 8.76050000000001e-07 0 8.80000000000001e-07 0 8.80100000000001e-07 1 8.81500000000001e-07 1 8.81550000000001e-07 0 8.82000000000001e-07 0 8.82050000000001e-07 0 8.86000000000001e-07 0 8.86100000000001e-07 1 8.87500000000001e-07 1 8.87550000000001e-07 0 8.88000000000001e-07 0 8.88050000000001e-07 0 8.92000000000001e-07 0 8.92100000000001e-07 1 8.93500000000001e-07 1 8.93550000000001e-07 0 8.94000000000001e-07 0 8.94050000000001e-07 0 8.98000000000001e-07 0 8.98100000000001e-07 1 8.99500000000001e-07 1 8.99550000000001e-07 0 9.00000000000001e-07 0 9.00050000000001e-07 0 9.04000000000001e-07 0 9.04100000000001e-07 1 9.05500000000001e-07 1 9.05550000000001e-07 0 9.06000000000001e-07 0 9.06050000000001e-07 0 9.10000000000001e-07 0 9.10100000000001e-07 1 9.11500000000001e-07 1 9.11550000000001e-07 0 9.12000000000001e-07 0 9.12050000000001e-07 0 9.16000000000001e-07 0 9.16100000000001e-07 1 9.17500000000001e-07 1 9.17550000000001e-07 0 9.18000000000002e-07 0 9.18050000000002e-07 0 9.22000000000002e-07 0 9.22100000000002e-07 1 9.23500000000002e-07 1 9.23550000000002e-07 0 9.24000000000002e-07 0 9.24050000000002e-07 0 9.28000000000002e-07 0 9.28100000000002e-07 1 9.29500000000002e-07 1 9.29550000000002e-07 0 9.30000000000002e-07 0 9.30050000000002e-07 0 9.34000000000002e-07 0 9.34100000000002e-07 1 9.35500000000002e-07 1 9.35550000000002e-07 0 9.36000000000002e-07 0 9.36050000000002e-07 0 9.40000000000002e-07 0 9.40100000000002e-07 1 9.41500000000002e-07 1 9.41550000000002e-07 0 9.42000000000002e-07 0 9.42050000000002e-07 0 9.46000000000002e-07 0 9.46100000000002e-07 1 9.47500000000002e-07 1 9.47550000000002e-07 0 9.48000000000002e-07 0 9.48050000000002e-07 0 9.52000000000002e-07 0 9.52100000000002e-07 1 9.53500000000002e-07 1 9.53550000000002e-07 0 9.54000000000002e-07 0 9.54050000000001e-07 0 9.58000000000002e-07 0 9.58100000000002e-07 1 9.59500000000002e-07 1 9.59550000000001e-07 0 9.60000000000002e-07 0 9.60050000000002e-07 0 9.64000000000002e-07 0 9.64100000000002e-07 1 9.65500000000002e-07 1 9.65550000000001e-07 0 9.66000000000002e-07 0 9.66050000000002e-07 0 9.70000000000002e-07 0 9.70100000000002e-07 1 9.71500000000002e-07 1 9.71550000000002e-07 0 9.72000000000002e-07 0 9.72050000000002e-07 0 9.76000000000002e-07 0 9.76100000000002e-07 1 9.77500000000002e-07 1 9.77550000000002e-07 0 9.78000000000002e-07 0 9.78050000000002e-07 0 9.82000000000002e-07 0 9.82100000000002e-07 1 9.83500000000002e-07 1 9.83550000000002e-07 0 9.84000000000002e-07 0 9.84050000000002e-07 0 9.88000000000002e-07 0 9.88100000000002e-07 1 9.89500000000002e-07 1 9.89550000000002e-07 0 9.90000000000002e-07 0 9.90050000000002e-07 0 9.94000000000002e-07 0 9.94100000000002e-07 1 9.95500000000002e-07 1 9.95550000000002e-07 0 9.96000000000002e-07 0 9.96050000000002e-07 0 1e-06 0 1.0001e-06 1 1.0015e-06 1 1.00155e-06 0 1.002e-06 0 1.00205e-06 0 1.006e-06 0 1.0061e-06 1 1.0075e-06 1 1.00755e-06 0 1.008e-06 0 1.00805e-06 0 1.012e-06 0 1.0121e-06 1 1.0135e-06 1 1.01355e-06 0 1.014e-06 0 1.01405e-06 0 1.018e-06 0 1.0181e-06 1 1.0195e-06 1 1.01955e-06 0 1.02e-06 0 1.02005e-06 0 1.024e-06 0 1.0241e-06 1 1.0255e-06 1 1.02555e-06 0 1.026e-06 0 1.02605e-06 0 1.03e-06 0 1.0301e-06 1 1.0315e-06 1 1.03155e-06 0 1.032e-06 0 1.03205e-06 0 1.036e-06 0 1.0361e-06 1 1.0375e-06 1 1.03755e-06 0 1.038e-06 0 1.03805e-06 0 1.042e-06 0 1.0421e-06 1 1.0435e-06 1 1.04355e-06 0 1.044e-06 0 1.04405e-06 0 1.048e-06 0 1.0481e-06 1 1.0495e-06 1 1.04955e-06 0 1.05e-06 0 1.05005e-06 0 1.054e-06 0 1.0541e-06 1 1.0555e-06 1 1.05555e-06 0 1.056e-06 0 1.05605e-06 0 1.06e-06 0 1.0601e-06 1 1.0615e-06 1 1.06155e-06 0 1.062e-06 0 1.06205e-06 0 1.066e-06 0 1.0661e-06 1 1.0675e-06 1 1.06755e-06 0 1.068e-06 0 1.06805e-06 0 1.072e-06 0 1.0721e-06 1 1.0735e-06 1 1.07355e-06 0 1.074e-06 0 1.07405e-06 0 1.078e-06 0 1.0781e-06 1 1.0795e-06 1 1.07955e-06 0 1.08e-06 0 1.08005e-06 0 1.084e-06 0 1.0841e-06 1 1.0855e-06 1 1.08555e-06 0 1.086e-06 0 1.08605e-06 0 1.09e-06 0 1.0901e-06 1 1.0915e-06 1 1.09155e-06 0 1.092e-06 0 1.09205e-06 0 1.096e-06 0 1.0961e-06 1 1.0975e-06 1 1.09755e-06 0 1.098e-06 0 1.09805e-06 0 1.102e-06 0 1.1021e-06 1 1.1035e-06 1 1.10355e-06 0 1.104e-06 0 1.10405e-06 0 1.108e-06 0 1.1081e-06 1 1.1095e-06 1 1.10955e-06 0 1.11e-06 0 1.11005e-06 0 1.114e-06 0 1.1141e-06 1 1.1155e-06 1 1.11555e-06 0 1.116e-06 0 1.11605e-06 0 1.12e-06 0 1.1201e-06 1 1.1215e-06 1 1.12155e-06 0 1.122e-06 0 1.12205e-06 0 1.126e-06 0 1.1261e-06 1 1.1275e-06 1 1.12755e-06 0 1.128e-06 0 1.12805e-06 0 1.132e-06 0 1.1321e-06 1 1.1335e-06 1 1.13355e-06 0 1.134e-06 0 1.13405e-06 0 1.138e-06 0 1.1381e-06 1 1.1395e-06 1 1.13955e-06 0 1.14e-06 0 1.14005e-06 0 1.144e-06 0 1.1441e-06 1 1.1455e-06 1 1.14555e-06 0 1.146e-06 0 1.14605e-06 0 1.15e-06 0 1.1501e-06 1 1.1515e-06 1 1.15155e-06 0 1.152e-06 0 1.15205e-06 0 1.156e-06 0 1.1561e-06 1 1.1575e-06 1 1.15755e-06 0 1.158e-06 0 1.15805e-06 0 1.162e-06 0 1.1621e-06 1 1.1635e-06 1 1.16355e-06 0 1.164e-06 0 1.16405e-06 0 1.168e-06 0 1.1681e-06 1 1.1695e-06 1 1.16955e-06 0 1.17e-06 0 1.17005e-06 0 1.174e-06 0 1.1741e-06 1 1.1755e-06 1 1.17555e-06 0 1.176e-06 0 1.17605e-06 0 1.18e-06 0 1.1801e-06 1 1.1815e-06 1 1.18155e-06 0 1.182e-06 0 1.18205e-06 0 1.186e-06 0 1.1861e-06 1 1.1875e-06 1 1.18755e-06 0 1.188e-06 0 1.18805e-06 0 1.192e-06 0 1.1921e-06 1 1.1935e-06 1 1.19355e-06 0 1.194e-06 0 1.19405e-06 0 1.198e-06 0 1.1981e-06 1 1.1995e-06 1 1.19955e-06 0 1.2e-06 0 1.20005e-06 0 1.204e-06 0 1.2041e-06 1 1.2055e-06 1 1.20555e-06 0 1.206e-06 0 1.20605e-06 0 1.21e-06 0 1.2101e-06 1 1.2115e-06 1 1.21155e-06 0 1.212e-06 0 1.21205e-06 0 1.216e-06 0 1.2161e-06 1 1.2175e-06 1 1.21755e-06 0 1.218e-06 0 1.21805e-06 0 1.222e-06 0 1.2221e-06 1 1.2235e-06 1 1.22355e-06 0 1.224e-06 0 1.22405e-06 0 1.228e-06 0 1.2281e-06 1 1.2295e-06 1 1.22955e-06 0 1.23e-06 0 1.23005e-06 0 1.234e-06 0 1.2341e-06 1 1.2355e-06 1 1.23555e-06 0 1.236e-06 0 1.23605e-06 0 1.24e-06 0 1.2401e-06 1 1.2415e-06 1 1.24155e-06 0 1.242e-06 0 1.24205e-06 0 1.246e-06 0 1.2461e-06 1 1.2475e-06 1 1.24755e-06 0 1.248e-06 0 1.24805e-06 0 1.252e-06 0 1.2521e-06 1 1.2535e-06 1 1.25355e-06 0 1.254e-06 0 1.25405e-06 0 1.258e-06 0 1.2581e-06 1 1.2595e-06 1 1.25955e-06 0 1.26e-06 0 1.26005e-06 0 1.264e-06 0 1.2641e-06 1 1.2655e-06 1 1.26555e-06 0 1.266e-06 0 1.26605e-06 0 1.27e-06 0 1.2701e-06 1 1.2715e-06 1 1.27155e-06 0 1.272e-06 0 1.27205e-06 0 1.276e-06 0 1.2761e-06 1 1.2775e-06 1 1.27755e-06 0 1.278e-06 0 1.27805e-06 0 1.282e-06 0 1.2821e-06 1 1.2835e-06 1 1.28355e-06 0 1.284e-06 0 1.28405e-06 0 1.288e-06 0 1.2881e-06 1 1.2895e-06 1 1.28955e-06 0 1.29e-06 0 1.29005e-06 0 1.294e-06 0 1.2941e-06 1 1.2955e-06 1 1.29555e-06 0 1.296e-06 0 1.29605e-06 0 1.3e-06 0 1.3001e-06 1 1.3015e-06 1 1.30155e-06 0 1.302e-06 0 1.30205e-06 0 1.306e-06 0 1.3061e-06 1 1.3075e-06 1 1.30755e-06 0 1.308e-06 0 1.30805e-06 0 1.312e-06 0 1.3121e-06 1 1.3135e-06 1 1.31355e-06 0 1.314e-06 0 1.31405e-06 0 1.318e-06 0 1.3181e-06 1 1.3195e-06 1 1.31955e-06 0 1.32e-06 0 1.32005e-06 0 1.324e-06 0 1.3241e-06 1 1.3255e-06 1 1.32555e-06 0 1.326e-06 0 1.32605e-06 0 1.33e-06 0 1.3301e-06 1 1.3315e-06 1 1.33155e-06 0 1.332e-06 0 1.33205e-06 0 1.336e-06 0 1.3361e-06 1 1.3375e-06 1 1.33755e-06 0 1.338e-06 0 1.33805e-06 0 1.342e-06 0 1.3421e-06 1 1.3435e-06 1 1.34355e-06 0 1.344e-06 0 1.34405e-06 0 1.348e-06 0 1.3481e-06 1 1.3495e-06 1 1.34955e-06 0 1.35e-06 0 1.35005e-06 0 1.354e-06 0 1.3541e-06 1 1.3555e-06 1 1.35555e-06 0 1.356e-06 0 1.35605e-06 0 1.36e-06 0 1.3601e-06 1 1.3615e-06 1 1.36155e-06 0 1.362e-06 0 1.36205e-06 0 1.366e-06 0 1.3661e-06 1 1.3675e-06 1 1.36755e-06 0 1.368e-06 0 1.36805e-06 0 1.372e-06 0 1.3721e-06 1 1.3735e-06 1 1.37355e-06 0 1.374e-06 0 1.37405e-06 0 1.378e-06 0 1.3781e-06 1 1.3795e-06 1 1.37955e-06 0 1.38e-06 0 1.38005e-06 0 1.384e-06 0 1.3841e-06 1 1.3855e-06 1 1.38555e-06 0 1.386e-06 0 1.38605e-06 0 1.39e-06 0 1.3901e-06 1 1.3915e-06 1 1.39155e-06 0 1.392e-06 0 1.39205e-06 0 1.396e-06 0 1.3961e-06 1 1.3975e-06 1 1.39755e-06 0 1.398e-06 0 1.39805e-06 0 1.402e-06 0 1.4021e-06 1 1.4035e-06 1 1.40355e-06 0 1.404e-06 0 1.40405e-06 0 1.408e-06 0 1.4081e-06 1 1.4095e-06 1 1.40955e-06 0 1.41e-06 0 1.41005e-06 0 1.414e-06 0 1.4141e-06 1 1.4155e-06 1 1.41555e-06 0 1.416e-06 0 1.41605e-06 0 1.42e-06 0 1.4201e-06 1 1.4215e-06 1 1.42155e-06 0 1.422e-06 0 1.42205e-06 0 1.426e-06 0 1.4261e-06 1 1.4275e-06 1 1.42755e-06 0 1.428e-06 0 1.42805e-06 0 1.432e-06 0 1.4321e-06 1 1.4335e-06 1 1.43355e-06 0 1.434e-06 0 1.43405e-06 0 1.438e-06 0 1.4381e-06 1 1.4395e-06 1 1.43955e-06 0 1.44e-06 0 1.44005e-06 0 1.444e-06 0 1.4441e-06 1 1.4455e-06 1 1.44555e-06 0 1.446e-06 0 1.44605e-06 0 1.45e-06 0 1.4501e-06 1 1.4515e-06 1 1.45155e-06 0 1.452e-06 0 1.45205e-06 0 1.456e-06 0 1.4561e-06 1 1.4575e-06 1 1.45755e-06 0 1.458e-06 0 1.45805e-06 0 1.462e-06 0 1.4621e-06 1 1.4635e-06 1 1.46355e-06 0 1.464e-06 0 1.46405e-06 0 1.468e-06 0 1.4681e-06 1 1.4695e-06 1 1.46955e-06 0 1.47e-06 0 1.47005e-06 0 1.474e-06 0 1.4741e-06 1 1.4755e-06 1 1.47555e-06 0 1.476e-06 0 1.47605e-06 0 1.48e-06 0 1.4801e-06 1 1.4815e-06 1 1.48155e-06 0 1.482e-06 0 1.48205e-06 0 1.486e-06 0 1.4861e-06 1 1.4875e-06 1 1.48755e-06 0 1.488e-06 0 1.48805e-06 0 1.492e-06 0 1.4921e-06 1 1.4935e-06 1 1.49355e-06 0 1.494e-06 0 1.49405e-06 0 1.498e-06 0 1.4981e-06 1 1.4995e-06 1 1.49955e-06 0 1.5e-06 0 1.50005e-06 0 1.504e-06 0 1.5041e-06 1 1.5055e-06 1 1.50555e-06 0 1.506e-06 0 1.50605e-06 0 1.51e-06 0 1.5101e-06 1 1.5115e-06 1 1.51155e-06 0 1.512e-06 0 1.51205e-06 0 1.516e-06 0 1.5161e-06 1 1.5175e-06 1 1.51755e-06 0 1.518e-06 0 1.51805e-06 0 1.522e-06 0 1.5221e-06 1 1.5235e-06 1 1.52355e-06 0 1.524e-06 0 1.52405e-06 0 1.528e-06 0 1.5281e-06 1 1.5295e-06 1 1.52955e-06 0 1.53e-06 0 1.53005e-06 0 1.534e-06 0 1.5341e-06 1 1.5355e-06 1 1.53555e-06 0 1.536e-06 0 1.53605e-06 0 1.54e-06 0 1.5401e-06 1 1.5415e-06 1 1.54155e-06 0 1.542e-06 0 1.54205e-06 0 1.546e-06 0 1.5461e-06 1 1.5475e-06 1 1.54755e-06 0 1.548e-06 0 1.54805e-06 0 1.552e-06 0 1.5521e-06 1 1.5535e-06 1 1.55355e-06 0 1.554e-06 0 1.55405e-06 0 1.558e-06 0 1.5581e-06 1 1.5595e-06 1 1.55955e-06 0 1.56e-06 0 1.56005e-06 0 1.564e-06 0 1.5641e-06 1 1.5655e-06 1 1.56555e-06 0 1.566e-06 0 1.56605e-06 0 1.57e-06 0 1.5701e-06 1 1.5715e-06 1 1.57155e-06 0 1.572e-06 0 1.57205e-06 0 1.576e-06 0 1.5761e-06 1 1.5775e-06 1 1.57755e-06 0 1.578e-06 0 1.57805e-06 0 1.582e-06 0 1.5821e-06 1 1.5835e-06 1 1.58355e-06 0 1.584e-06 0 1.58405e-06 0 1.588e-06 0 1.5881e-06 1 1.5895e-06 1 1.58955e-06 0 1.59e-06 0 1.59005e-06 0 1.594e-06 0 1.5941e-06 1 1.5955e-06 1 1.59555e-06 0 1.596e-06 0 1.59605e-06 0 1.6e-06 0 1.6001e-06 1 1.6015e-06 1 1.60155e-06 0 1.602e-06 0 1.60205e-06 0 1.606e-06 0 1.6061e-06 1 1.6075e-06 1 1.60755e-06 0 1.608e-06 0 1.60805e-06 0 1.612e-06 0 1.6121e-06 1 1.6135e-06 1 1.61355e-06 0 1.614e-06 0 1.61405e-06 0 1.618e-06 0 1.6181e-06 1 1.6195e-06 1 1.61955e-06 0 1.62e-06 0 1.62005e-06 0 1.624e-06 0 1.6241e-06 1 1.6255e-06 1 1.62555e-06 0 1.626e-06 0 1.62605e-06 0 1.63e-06 0 1.6301e-06 1 1.6315e-06 1 1.63155e-06 0 1.632e-06 0 1.63205e-06 0 1.636e-06 0 1.6361e-06 1 1.6375e-06 1 1.63755e-06 0 1.638e-06 0 1.63805e-06 0 1.642e-06 0 1.6421e-06 1 1.6435e-06 1 1.64355e-06 0 1.644e-06 0 1.64405e-06 0 1.648e-06 0 1.6481e-06 1 1.6495e-06 1 1.64955e-06 0 1.65e-06 0 1.65005e-06 0 1.654e-06 0 1.6541e-06 1 1.6555e-06 1 1.65555e-06 0 1.656e-06 0 1.65605e-06 0 1.66e-06 0 1.6601e-06 1 1.6615e-06 1 1.66155e-06 0 1.662e-06 0 1.66205e-06 0 1.666e-06 0 1.6661e-06 1 1.6675e-06 1 1.66755e-06 0 1.668e-06 0 1.66805e-06 0 1.672e-06 0 1.6721e-06 1 1.6735e-06 1 1.67355e-06 0 1.674e-06 0 1.67405e-06 0 1.678e-06 0 1.6781e-06 1 1.6795e-06 1 1.67955e-06 0 1.68e-06 0 1.68005e-06 0 1.684e-06 0 1.6841e-06 1 1.6855e-06 1 1.68555e-06 0 1.686e-06 0 1.68605e-06 0 1.69e-06 0 1.69010000000001e-06 1 1.6915e-06 1 1.69155e-06 0 1.692e-06 0 1.69205e-06 0 1.69600000000001e-06 0 1.69610000000001e-06 1 1.6975e-06 1 1.69755e-06 0 1.698e-06 0 1.69805e-06 0 1.70200000000001e-06 0 1.70210000000001e-06 1 1.7035e-06 1 1.70355e-06 0 1.704e-06 0 1.70405e-06 0 1.70800000000001e-06 0 1.70810000000001e-06 1 1.7095e-06 1 1.70955e-06 0 1.71000000000001e-06 0 1.71005e-06 0 1.71400000000001e-06 0 1.71410000000001e-06 1 1.71550000000001e-06 1 1.71555e-06 0 1.71600000000001e-06 0 1.71605e-06 0 1.72000000000001e-06 0 1.72010000000001e-06 1 1.72150000000001e-06 1 1.72155e-06 0 1.72200000000001e-06 0 1.72205e-06 0 1.72600000000001e-06 0 1.72610000000001e-06 1 1.72750000000001e-06 1 1.72755e-06 0 1.72800000000001e-06 0 1.72805e-06 0 1.73200000000001e-06 0 1.73210000000001e-06 1 1.73350000000001e-06 1 1.73355e-06 0 1.73400000000001e-06 0 1.73405000000001e-06 0 1.73800000000001e-06 0 1.73810000000001e-06 1 1.73950000000001e-06 1 1.73955000000001e-06 0 1.74000000000001e-06 0 1.74005000000001e-06 0 1.74400000000001e-06 0 1.74410000000001e-06 1 1.74550000000001e-06 1 1.74555000000001e-06 0 1.74600000000001e-06 0 1.74605000000001e-06 0 1.75000000000001e-06 0 1.75010000000001e-06 1 1.75150000000001e-06 1 1.75155000000001e-06 0 1.75200000000001e-06 0 1.75205000000001e-06 0 1.75600000000001e-06 0 1.75610000000001e-06 1 1.75750000000001e-06 1 1.75755000000001e-06 0 1.75800000000001e-06 0 1.75805000000001e-06 0 1.76200000000001e-06 0 1.76210000000001e-06 1 1.76350000000001e-06 1 1.76355000000001e-06 0 1.76400000000001e-06 0 1.76405000000001e-06 0 1.76800000000001e-06 0 1.76810000000001e-06 1 1.76950000000001e-06 1 1.76955000000001e-06 0 1.77000000000001e-06 0 1.77005000000001e-06 0 1.77400000000001e-06 0 1.77410000000001e-06 1 1.77550000000001e-06 1 1.77555000000001e-06 0 1.77600000000001e-06 0 1.77605000000001e-06 0 1.78000000000001e-06 0 1.78010000000001e-06 1 1.78150000000001e-06 1 1.78155000000001e-06 0 1.78200000000001e-06 0 1.78205000000001e-06 0 1.78600000000001e-06 0 1.78610000000001e-06 1 1.78750000000001e-06 1 1.78755000000001e-06 0 1.78800000000001e-06 0 1.78805000000001e-06 0 1.79200000000001e-06 0 1.79210000000001e-06 1 1.79350000000001e-06 1 1.79355000000001e-06 0 1.79400000000001e-06 0 1.79405000000001e-06 0 1.79800000000001e-06 0 1.79810000000001e-06 1 1.79950000000001e-06 1 1.79955000000001e-06 0 1.80000000000001e-06 0 1.80005000000001e-06 0 1.80400000000001e-06 0 1.80410000000001e-06 1 1.80550000000001e-06 1 1.80555000000001e-06 0 1.80600000000001e-06 0 1.80605000000001e-06 0 1.81000000000001e-06 0 1.81010000000001e-06 1 1.81150000000001e-06 1 1.81155000000001e-06 0 1.81200000000001e-06 0 1.81205000000001e-06 0 1.81600000000001e-06 0 1.81610000000001e-06 1 1.81750000000001e-06 1 1.81755000000001e-06 0 1.81800000000001e-06 0 1.81805000000001e-06 0 1.82200000000001e-06 0 1.82210000000001e-06 1 1.82350000000001e-06 1 1.82355000000001e-06 0 1.82400000000001e-06 0 1.82405000000001e-06 0 1.82800000000001e-06 0 1.82810000000001e-06 1 1.82950000000001e-06 1 1.82955000000001e-06 0 1.83000000000001e-06 0 1.83005000000001e-06 0 1.83400000000001e-06 0 1.83410000000001e-06 1 1.83550000000001e-06 1 1.83555000000001e-06 0 1.83600000000001e-06 0 1.83605000000001e-06 0 1.84000000000001e-06 0 1.84010000000001e-06 1 1.84150000000001e-06 1 1.84155000000001e-06 0 1.84200000000001e-06 0 1.84205000000001e-06 0 1.84600000000001e-06 0 1.84610000000001e-06 1 1.84750000000001e-06 1 1.84755000000001e-06 0 1.84800000000001e-06 0 1.84805000000001e-06 0 1.85200000000001e-06 0 1.85210000000001e-06 1 1.85350000000001e-06 1 1.85355000000001e-06 0 1.85400000000001e-06 0 1.85405000000001e-06 0 1.85800000000001e-06 0 1.85810000000001e-06 1 1.85950000000001e-06 1 1.85955000000001e-06 0 1.86000000000001e-06 0 1.86005000000001e-06 0 1.86400000000001e-06 0 1.86410000000001e-06 1 1.86550000000001e-06 1 1.86555000000001e-06 0 1.86600000000001e-06 0 1.86605000000001e-06 0 1.87000000000001e-06 0 1.87010000000001e-06 1 1.87150000000001e-06 1 1.87155000000001e-06 0 1.87200000000001e-06 0 1.87205000000001e-06 0 1.87600000000001e-06 0 1.87610000000001e-06 1 1.87750000000001e-06 1 1.87755000000001e-06 0 1.87800000000001e-06 0 1.87805000000001e-06 0 1.88200000000001e-06 0 1.88210000000001e-06 1 1.88350000000001e-06 1 1.88355000000001e-06 0 1.88400000000001e-06 0 1.88405000000001e-06 0 1.88800000000001e-06 0 1.88810000000001e-06 1 1.88950000000001e-06 1 1.88955000000001e-06 0 1.89000000000001e-06 0 1.89005000000001e-06 0 1.89400000000001e-06 0 1.89410000000001e-06 1 1.89550000000001e-06 1 1.89555000000001e-06 0 1.89600000000001e-06 0 1.89605000000001e-06 0 1.90000000000001e-06 0 1.90010000000001e-06 1 1.90150000000001e-06 1 1.90155000000001e-06 0 1.90200000000001e-06 0 1.90205000000001e-06 0 1.90600000000001e-06 0 1.90610000000001e-06 1 1.90750000000001e-06 1 1.90755000000001e-06 0 1.90800000000001e-06 0 1.90805000000001e-06 0 1.91200000000001e-06 0 1.91210000000001e-06 1 1.91350000000001e-06 1 1.91355000000001e-06 0 1.91400000000001e-06 0 1.91405000000001e-06 0 1.91800000000001e-06 0 1.9181e-06 1 1.91950000000001e-06 1 1.91955000000001e-06 0 1.92e-06 0 1.92005000000001e-06 0 1.924e-06 0 1.9241e-06 1 1.9255e-06 1 1.92555e-06 0 1.926e-06 0 1.92605e-06 0 1.93e-06 0 1.9301e-06 1 1.9315e-06 1 1.93155e-06 0 1.932e-06 0 1.93205e-06 0 1.936e-06 0 1.9361e-06 1 1.9375e-06 1 1.93755e-06 0 1.938e-06 0 1.93805e-06 0 1.942e-06 0 1.9421e-06 1 1.9435e-06 1 1.94355e-06 0 1.944e-06 0 1.94405e-06 0 1.948e-06 0 1.9481e-06 1 1.9495e-06 1 1.94955e-06 0 1.95e-06 0 1.95005e-06 0 1.954e-06 0 1.9541e-06 1 1.9555e-06 1 1.95555e-06 0 1.956e-06 0 1.95605e-06 0 1.96e-06 0 1.9601e-06 1 1.9615e-06 1 1.96155e-06 0 1.962e-06 0 1.96205e-06 0 1.966e-06 0 1.9661e-06 1 1.9675e-06 1 1.96755e-06 0 1.968e-06 0 1.96805e-06 0 1.972e-06 0 1.9721e-06 1 1.9735e-06 1 1.97355e-06 0 1.974e-06 0 1.97405e-06 0 1.978e-06 0 1.9781e-06 1 1.9795e-06 1 1.97955e-06 0 1.98e-06 0 1.98005e-06 0 1.984e-06 0 1.9841e-06 1 1.9855e-06 1 1.98555e-06 0 1.986e-06 0 1.98605e-06 0 1.99e-06 0 1.9901e-06 1 1.9915e-06 1 1.99155e-06 0 1.992e-06 0 1.99205e-06 0 1.996e-06 0 1.9961e-06 1 1.9975e-06 1 1.99755e-06 0 1.998e-06 0 1.99805e-06 0 2.002e-06 0 2.0021e-06 1 2.0035e-06 1 2.00355e-06 0 2.004e-06 0 2.00405e-06 0 2.008e-06 0 2.0081e-06 1 2.0095e-06 1 2.00955e-06 0 2.01e-06 0 2.01005e-06 0 2.014e-06 0 2.0141e-06 1 2.0155e-06 1 2.01555e-06 0 2.016e-06 0 2.01605e-06 0 2.02e-06 0 2.0201e-06 1 2.0215e-06 1 2.02155e-06 0 2.022e-06 0 2.02205e-06 0 2.026e-06 0 2.0261e-06 1 2.0275e-06 1 2.02755e-06 0 2.028e-06 0 2.02805e-06 0 2.032e-06 0 2.0321e-06 1 2.0335e-06 1 2.03355e-06 0 2.034e-06 0 2.03405e-06 0 2.038e-06 0 2.0381e-06 1 2.0395e-06 1 2.03955e-06 0 2.04e-06 0 2.04005e-06 0 2.044e-06 0 2.0441e-06 1 2.0455e-06 1 2.04555e-06 0 2.046e-06 0 2.04605e-06 0 2.05e-06 0 2.0501e-06 1 2.0515e-06 1 2.05155e-06 0 2.052e-06 0 2.05205e-06 0 2.056e-06 0 2.0561e-06 1 2.0575e-06 1 2.05755e-06 0 2.058e-06 0 2.05805e-06 0 2.062e-06 0 2.0621e-06 1 2.0635e-06 1 2.06355e-06 0 2.064e-06 0 2.06405e-06 0 2.068e-06 0 2.0681e-06 1 2.0695e-06 1 2.06955e-06 0 2.07e-06 0 2.07005e-06 0 2.07399999999999e-06 0 2.07409999999999e-06 1 2.07549999999999e-06 1 2.07554999999999e-06 0 2.07599999999999e-06 0 2.07604999999999e-06 0 2.07999999999999e-06 0 2.08009999999999e-06 1 2.08149999999999e-06 1 2.08154999999999e-06 0 2.08199999999999e-06 0 2.08204999999999e-06 0 2.08599999999999e-06 0 2.08609999999999e-06 1 2.08749999999999e-06 1 2.08754999999999e-06 0 2.08799999999999e-06 0 2.08804999999999e-06 0 2.09199999999999e-06 0 2.09209999999999e-06 1 2.09349999999999e-06 1 2.09354999999999e-06 0 2.09399999999999e-06 0 2.09404999999999e-06 0 2.09799999999999e-06 0 2.09809999999999e-06 1 2.09949999999999e-06 1 2.09954999999999e-06 0 2.09999999999999e-06 0 2.10004999999999e-06 0 2.10399999999999e-06 0 2.10409999999999e-06 1 2.10549999999999e-06 1 2.10554999999999e-06 0 2.10599999999999e-06 0 2.10604999999999e-06 0 2.10999999999999e-06 0 2.11009999999999e-06 1 2.11149999999999e-06 1 2.11154999999999e-06 0 2.11199999999999e-06 0 2.11204999999999e-06 0 2.11599999999999e-06 0 2.11609999999999e-06 1 2.11749999999999e-06 1 2.11754999999999e-06 0 2.11799999999999e-06 0 2.11804999999999e-06 0 2.12199999999999e-06 0 2.12209999999999e-06 1 2.12349999999999e-06 1 2.12354999999999e-06 0 2.12399999999999e-06 0 2.12404999999999e-06 0 2.12799999999999e-06 0 2.12809999999999e-06 1 2.12949999999999e-06 1 2.12954999999999e-06 0 2.12999999999999e-06 0 2.13004999999999e-06 0 2.13399999999999e-06 0 2.13409999999999e-06 1 2.13549999999999e-06 1 2.13554999999999e-06 0 2.13599999999999e-06 0 2.13604999999999e-06 0 2.13999999999999e-06 0 2.14009999999999e-06 1 2.14149999999999e-06 1 2.14154999999999e-06 0 2.14199999999999e-06 0 2.14204999999999e-06 0 2.14599999999999e-06 0 2.14609999999999e-06 1 2.14749999999999e-06 1 2.14754999999999e-06 0 2.14799999999999e-06 0 2.14804999999999e-06 0 2.15199999999999e-06 0 2.15209999999999e-06 1 2.15349999999999e-06 1 2.15354999999999e-06 0 2.15399999999999e-06 0 2.15404999999999e-06 0 2.15799999999999e-06 0 2.15809999999999e-06 1 2.15949999999999e-06 1 2.15954999999999e-06 0 2.15999999999999e-06 0 2.16004999999999e-06 0 2.16399999999999e-06 0 2.16409999999999e-06 1 2.16549999999999e-06 1 2.16554999999999e-06 0 2.16599999999999e-06 0 2.16604999999999e-06 0 2.16999999999999e-06 0 2.17009999999999e-06 1 2.17149999999999e-06 1 2.17154999999999e-06 0 2.17199999999999e-06 0 2.17204999999999e-06 0 2.17599999999999e-06 0 2.17609999999999e-06 1 2.17749999999999e-06 1 2.17754999999999e-06 0 2.17799999999999e-06 0 2.17804999999999e-06 0 2.18199999999999e-06 0 2.18209999999999e-06 1 2.18349999999999e-06 1 2.18354999999999e-06 0 2.18399999999999e-06 0 2.18404999999999e-06 0 2.18799999999999e-06 0 2.18809999999999e-06 1 2.18949999999999e-06 1 2.18954999999999e-06 0 2.18999999999999e-06 0 2.19004999999999e-06 0 2.19399999999999e-06 0 2.19409999999999e-06 1 2.19549999999999e-06 1 2.19554999999999e-06 0 2.19599999999999e-06 0 2.19604999999999e-06 0 2.19999999999999e-06 0 2.20009999999999e-06 1 2.20149999999999e-06 1 2.20154999999999e-06 0 2.20199999999999e-06 0 2.20204999999999e-06 0 2.20599999999999e-06 0 2.20609999999999e-06 1 2.20749999999999e-06 1 2.20754999999999e-06 0 2.20799999999999e-06 0 2.20804999999999e-06 0 2.21199999999999e-06 0 2.21209999999999e-06 1 2.21349999999999e-06 1 2.21354999999999e-06 0 2.21399999999999e-06 0 2.21404999999999e-06 0 2.21799999999999e-06 0 2.21809999999999e-06 1 2.21949999999999e-06 1 2.21954999999999e-06 0 2.21999999999999e-06 0 2.22004999999999e-06 0 2.22399999999998e-06 0 2.22409999999998e-06 1 2.22549999999998e-06 1 2.22554999999998e-06 0 2.22599999999998e-06 0 2.22604999999998e-06 0 2.22999999999998e-06 0 2.23009999999998e-06 1 2.23149999999998e-06 1 2.23154999999998e-06 0 2.23199999999998e-06 0 2.23204999999998e-06 0 2.23599999999998e-06 0 2.23609999999998e-06 1 2.23749999999998e-06 1 2.23754999999998e-06 0 2.23799999999998e-06 0 2.23804999999998e-06 0 2.24199999999998e-06 0 2.24209999999998e-06 1 2.24349999999998e-06 1 2.24354999999998e-06 0 2.24399999999998e-06 0 2.24404999999998e-06 0 2.24799999999998e-06 0 2.24809999999998e-06 1 2.24949999999998e-06 1 2.24954999999998e-06 0 2.24999999999998e-06 0 2.25004999999998e-06 0 2.25399999999998e-06 0 2.25409999999998e-06 1 2.25549999999998e-06 1 2.25554999999998e-06 0 2.25599999999998e-06 0 2.25604999999998e-06 0 2.25999999999998e-06 0 2.26009999999998e-06 1 2.26149999999998e-06 1 2.26154999999998e-06 0 2.26199999999998e-06 0 2.26204999999998e-06 0 2.26599999999998e-06 0 2.26609999999998e-06 1 2.26749999999998e-06 1 2.26754999999998e-06 0 2.26799999999998e-06 0 2.26804999999998e-06 0 2.27199999999998e-06 0 2.27209999999998e-06 1 2.27349999999998e-06 1 2.27354999999998e-06 0 2.27399999999998e-06 0 2.27404999999998e-06 0 2.27799999999998e-06 0 2.27809999999998e-06 1 2.27949999999998e-06 1 2.27954999999998e-06 0 2.27999999999998e-06 0 2.28004999999998e-06 0 2.28399999999998e-06 0 2.28409999999998e-06 1 2.28549999999998e-06 1 2.28554999999998e-06 0 2.28599999999998e-06 0 2.28604999999998e-06 0 2.28999999999998e-06 0 2.29009999999998e-06 1 2.29149999999998e-06 1 2.29154999999998e-06 0 2.29199999999998e-06 0 2.29204999999998e-06 0 2.29599999999998e-06 0 2.29609999999998e-06 1 2.29749999999998e-06 1 2.29754999999998e-06 0 2.29799999999998e-06 0 2.29804999999998e-06 0 2.30199999999998e-06 0 2.30209999999998e-06 1 2.30349999999998e-06 1 2.30354999999998e-06 0 2.30399999999998e-06 0 2.30404999999998e-06 0 2.30799999999998e-06 0 2.30809999999998e-06 1 2.30949999999998e-06 1 2.30954999999998e-06 0 2.30999999999998e-06 0 2.31004999999998e-06 0 2.31399999999998e-06 0 2.31409999999998e-06 1 2.31549999999998e-06 1 2.31554999999998e-06 0 2.31599999999998e-06 0 2.31604999999998e-06 0 2.31999999999998e-06 0 2.32009999999998e-06 1 2.32149999999998e-06 1 2.32154999999998e-06 0 2.32199999999998e-06 0 2.32204999999998e-06 0 2.32599999999998e-06 0 2.32609999999998e-06 1 2.32749999999998e-06 1 2.32754999999998e-06 0 2.32799999999998e-06 0 2.32804999999998e-06 0 2.33199999999998e-06 0 2.33209999999998e-06 1 2.33349999999998e-06 1 2.33354999999998e-06 0 2.33399999999998e-06 0 2.33404999999998e-06 0 2.33799999999998e-06 0 2.33809999999998e-06 1 2.33949999999998e-06 1 2.33954999999998e-06 0 2.33999999999998e-06 0 2.34004999999998e-06 0 2.34399999999998e-06 0 2.34409999999998e-06 1 2.34549999999998e-06 1 2.34554999999998e-06 0 2.34599999999998e-06 0 2.34604999999998e-06 0 2.34999999999998e-06 0 2.35009999999998e-06 1 2.35149999999998e-06 1 2.35154999999998e-06 0 2.35199999999998e-06 0 2.35204999999998e-06 0 2.35599999999998e-06 0 2.35609999999998e-06 1 2.35749999999998e-06 1 2.35754999999998e-06 0 2.35799999999998e-06 0 2.35804999999998e-06 0 2.36199999999998e-06 0 2.36209999999998e-06 1 2.36349999999998e-06 1 2.36354999999998e-06 0 2.36399999999998e-06 0 2.36404999999998e-06 0 2.36799999999998e-06 0 2.36809999999998e-06 1 2.36949999999998e-06 1 2.36954999999998e-06 0 2.36999999999998e-06 0 2.37004999999998e-06 0 2.37399999999998e-06 0 2.37409999999997e-06 1 2.37549999999997e-06 1 2.37554999999998e-06 0 2.37599999999997e-06 0 2.37604999999997e-06 0 2.37999999999997e-06 0 2.38009999999997e-06 1 2.38149999999997e-06 1 2.38154999999997e-06 0 2.38199999999997e-06 0 2.38204999999997e-06 0 2.38599999999997e-06 0 2.38609999999997e-06 1 2.38749999999997e-06 1 2.38754999999997e-06 0 2.38799999999997e-06 0 2.38804999999997e-06 0 2.39199999999997e-06 0 2.39209999999997e-06 1 2.39349999999997e-06 1 2.39354999999997e-06 0 2.39399999999997e-06 0 2.39404999999997e-06 0 2.39799999999997e-06 0 2.39809999999997e-06 1 2.39949999999997e-06 1 2.39954999999997e-06 0 2.39999999999997e-06 0 2.40004999999997e-06 0 2.40399999999997e-06 0 2.40409999999997e-06 1 2.40549999999997e-06 1 2.40554999999997e-06 0 2.40599999999997e-06 0 2.40604999999997e-06 0 2.40999999999997e-06 0 2.41009999999997e-06 1 2.41149999999997e-06 1 2.41154999999997e-06 0 2.41199999999997e-06 0 2.41204999999997e-06 0 2.41599999999997e-06 0 2.41609999999997e-06 1 2.41749999999997e-06 1 2.41754999999997e-06 0 2.41799999999997e-06 0 2.41804999999997e-06 0 2.42199999999997e-06 0 2.42209999999997e-06 1 2.42349999999997e-06 1 2.42354999999997e-06 0 2.42399999999997e-06 0 2.42404999999997e-06 0 2.42799999999997e-06 0 2.42809999999997e-06 1 2.42949999999997e-06 1 2.42954999999997e-06 0 2.42999999999997e-06 0 2.43004999999997e-06 0 2.43399999999997e-06 0 2.43409999999997e-06 1 2.43549999999997e-06 1 2.43554999999997e-06 0 2.43599999999997e-06 0 2.43604999999997e-06 0 2.43999999999997e-06 0 2.44009999999997e-06 1 2.44149999999997e-06 1 2.44154999999997e-06 0 2.44199999999997e-06 0 2.44204999999997e-06 0 2.44599999999997e-06 0 2.44609999999997e-06 1 2.44749999999997e-06 1 2.44754999999997e-06 0 2.44799999999997e-06 0 2.44804999999997e-06 0 2.45199999999997e-06 0 2.45209999999997e-06 1 2.45349999999997e-06 1 2.45354999999997e-06 0 2.45399999999997e-06 0 2.45404999999997e-06 0 2.45799999999997e-06 0 2.45809999999997e-06 1 2.45949999999997e-06 1 2.45954999999997e-06 0 2.45999999999997e-06 0 2.46004999999997e-06 0 2.46399999999997e-06 0 2.46409999999997e-06 1 2.46549999999997e-06 1 2.46554999999997e-06 0 2.46599999999997e-06 0 2.46604999999997e-06 0 2.46999999999997e-06 0 2.47009999999997e-06 1 2.47149999999997e-06 1 2.47154999999997e-06 0 2.47199999999997e-06 0 2.47204999999997e-06 0 2.47599999999997e-06 0 2.47609999999997e-06 1 2.47749999999997e-06 1 2.47754999999997e-06 0 2.47799999999997e-06 0 2.47804999999997e-06 0 2.48199999999997e-06 0 2.48209999999997e-06 1 2.48349999999997e-06 1 2.48354999999997e-06 0 2.48399999999997e-06 0 2.48404999999997e-06 0 2.48799999999997e-06 0 2.48809999999997e-06 1 2.48949999999997e-06 1 2.48954999999997e-06 0 2.48999999999997e-06 0 2.49004999999997e-06 0 2.49399999999997e-06 0 2.49409999999997e-06 1 2.49549999999997e-06 1 2.49554999999997e-06 0 2.49599999999997e-06 0 2.49604999999997e-06 0 2.49999999999997e-06 0 2.50009999999997e-06 1 2.50149999999997e-06 1 2.50154999999997e-06 0 2.50199999999997e-06 0 2.50204999999997e-06 0 2.50599999999997e-06 0 2.50609999999997e-06 1 2.50749999999997e-06 1 2.50754999999997e-06 0 2.50799999999997e-06 0 2.50804999999997e-06 0 2.51199999999997e-06 0 2.51209999999997e-06 1 2.51349999999997e-06 1 2.51354999999997e-06 0 2.51399999999997e-06 0 2.51404999999997e-06 0 2.51799999999997e-06 0 2.51809999999997e-06 1 2.51949999999997e-06 1 2.51954999999997e-06 0 2.51999999999997e-06 0 2.52004999999997e-06 0 2.52399999999997e-06 0 2.52409999999996e-06 1 2.52549999999997e-06 1 2.52554999999997e-06 0 2.52599999999996e-06 0 2.52604999999996e-06 0 2.52999999999996e-06 0 2.53009999999996e-06 1 2.53149999999996e-06 1 2.53154999999996e-06 0 2.53199999999996e-06 0 2.53204999999996e-06 0 2.53599999999996e-06 0 2.53609999999996e-06 1 2.53749999999996e-06 1 2.53754999999996e-06 0 2.53799999999996e-06 0 2.53804999999996e-06 0 2.54199999999996e-06 0 2.54209999999996e-06 1 2.54349999999996e-06 1 2.54354999999996e-06 0 2.54399999999996e-06 0 2.54404999999996e-06 0 2.54799999999996e-06 0 2.54809999999996e-06 1 2.54949999999996e-06 1 2.54954999999996e-06 0 2.54999999999996e-06 0 2.55004999999996e-06 0 2.55399999999996e-06 0 2.55409999999996e-06 1 2.55549999999996e-06 1 2.55554999999996e-06 0 2.55599999999996e-06 0 2.55604999999996e-06 0 2.55999999999996e-06 0 2.56009999999996e-06 1 2.56149999999996e-06 1 2.56154999999996e-06 0 2.56199999999996e-06 0 2.56204999999996e-06 0 2.56599999999996e-06 0 2.56609999999996e-06 1 2.56749999999996e-06 1 2.56754999999996e-06 0 2.56799999999996e-06 0 2.56804999999996e-06 0 2.57199999999996e-06 0 2.57209999999996e-06 1 2.57349999999996e-06 1 2.57354999999996e-06 0 2.57399999999996e-06 0 2.57404999999996e-06 0 2.57799999999996e-06 0 2.57809999999996e-06 1 2.57949999999996e-06 1 2.57954999999996e-06 0 2.57999999999996e-06 0 2.58004999999996e-06 0 2.58399999999996e-06 0 2.58409999999996e-06 1 2.58549999999996e-06 1 2.58554999999996e-06 0 2.58599999999996e-06 0 2.58604999999996e-06 0 2.58999999999996e-06 0 2.59009999999996e-06 1 2.59149999999996e-06 1 2.59154999999996e-06 0 2.59199999999996e-06 0 2.59204999999996e-06 0 2.59599999999996e-06 0 2.59609999999996e-06 1 2.59749999999996e-06 1 2.59754999999996e-06 0 2.59799999999996e-06 0 2.59804999999996e-06 0 2.60199999999996e-06 0 2.60209999999996e-06 1 2.60349999999996e-06 1 2.60354999999996e-06 0 2.60399999999996e-06 0 2.60404999999996e-06 0 2.60799999999996e-06 0 2.60809999999996e-06 1 2.60949999999996e-06 1 2.60954999999996e-06 0 2.60999999999996e-06 0 2.61004999999996e-06 0 2.61399999999996e-06 0 2.61409999999996e-06 1 2.61549999999996e-06 1 2.61554999999996e-06 0 2.61599999999996e-06 0 2.61604999999996e-06 0 2.61999999999996e-06 0 2.62009999999996e-06 1 2.62149999999996e-06 1 2.62154999999996e-06 0 2.62199999999996e-06 0 2.62204999999996e-06 0 2.62599999999996e-06 0 2.62609999999996e-06 1 2.62749999999996e-06 1 2.62754999999996e-06 0 2.62799999999996e-06 0 2.62804999999996e-06 0 2.63199999999996e-06 0 2.63209999999996e-06 1 2.63349999999996e-06 1 2.63354999999996e-06 0 2.63399999999996e-06 0 2.63404999999996e-06 0 2.63799999999996e-06 0 2.63809999999996e-06 1 2.63949999999996e-06 1 2.63954999999996e-06 0 2.63999999999996e-06 0 2.64004999999996e-06 0 2.64399999999996e-06 0 2.64409999999996e-06 1 2.64549999999996e-06 1 2.64554999999996e-06 0 2.64599999999996e-06 0 2.64604999999996e-06 0 2.64999999999996e-06 0 2.65009999999996e-06 1 2.65149999999996e-06 1 2.65154999999996e-06 0 2.65199999999996e-06 0 2.65204999999996e-06 0 2.65599999999996e-06 0 2.65609999999996e-06 1 2.65749999999996e-06 1 2.65754999999996e-06 0 2.65799999999996e-06 0 2.65804999999996e-06 0 2.66199999999996e-06 0 2.66209999999996e-06 1 2.66349999999996e-06 1 2.66354999999996e-06 0 2.66399999999996e-06 0 2.66404999999996e-06 0 2.66799999999996e-06 0 2.66809999999996e-06 1 2.66949999999996e-06 1 2.66954999999996e-06 0 2.66999999999996e-06 0 2.67004999999996e-06 0 2.67399999999996e-06 0 2.67409999999996e-06 1 2.67549999999996e-06 1 2.67554999999996e-06 0 2.67599999999995e-06 0 2.67604999999996e-06 0 2.67999999999995e-06 0 2.68009999999995e-06 1 2.68149999999995e-06 1 2.68154999999995e-06 0 2.68199999999995e-06 0 2.68204999999995e-06 0 2.68599999999995e-06 0 2.68609999999995e-06 1 2.68749999999995e-06 1 2.68754999999995e-06 0 2.68799999999995e-06 0 2.68804999999995e-06 0 2.69199999999995e-06 0 2.69209999999995e-06 1 2.69349999999995e-06 1 2.69354999999995e-06 0 2.69399999999995e-06 0 2.69404999999995e-06 0 2.69799999999995e-06 0 2.69809999999995e-06 1 2.69949999999995e-06 1 2.69954999999995e-06 0 2.69999999999995e-06 0 2.70004999999995e-06 0 2.70399999999995e-06 0 2.70409999999995e-06 1 2.70549999999995e-06 1 2.70554999999995e-06 0 2.70599999999995e-06 0 2.70604999999995e-06 0 2.70999999999995e-06 0 2.71009999999995e-06 1 2.71149999999995e-06 1 2.71154999999995e-06 0 2.71199999999995e-06 0 2.71204999999995e-06 0 2.71599999999995e-06 0 2.71609999999995e-06 1 2.71749999999995e-06 1 2.71754999999995e-06 0 2.71799999999995e-06 0 2.71804999999995e-06 0 2.72199999999995e-06 0 2.72209999999995e-06 1 2.72349999999995e-06 1 2.72354999999995e-06 0 2.72399999999995e-06 0 2.72404999999995e-06 0 2.72799999999995e-06 0 2.72809999999995e-06 1 2.72949999999995e-06 1 2.72954999999995e-06 0 2.72999999999995e-06 0 2.73004999999995e-06 0 2.73399999999995e-06 0 2.73409999999995e-06 1 2.73549999999995e-06 1 2.73554999999995e-06 0 2.73599999999995e-06 0 2.73604999999995e-06 0 2.73999999999995e-06 0 2.74009999999995e-06 1 2.74149999999995e-06 1 2.74154999999995e-06 0 2.74199999999995e-06 0 2.74204999999995e-06 0 2.74599999999995e-06 0 2.74609999999995e-06 1 2.74749999999995e-06 1 2.74754999999995e-06 0 2.74799999999995e-06 0 2.74804999999995e-06 0 2.75199999999995e-06 0 2.75209999999995e-06 1 2.75349999999995e-06 1 2.75354999999995e-06 0 2.75399999999995e-06 0 2.75404999999995e-06 0 2.75799999999995e-06 0 2.75809999999995e-06 1 2.75949999999995e-06 1 2.75954999999995e-06 0 2.75999999999995e-06 0 2.76004999999995e-06 0 2.76399999999995e-06 0 2.76409999999995e-06 1 2.76549999999995e-06 1 2.76554999999995e-06 0 2.76599999999995e-06 0 2.76604999999995e-06 0 2.76999999999995e-06 0 2.77009999999995e-06 1 2.77149999999995e-06 1 2.77154999999995e-06 0 2.77199999999995e-06 0 2.77204999999995e-06 0 2.77599999999995e-06 0 2.77609999999995e-06 1 2.77749999999995e-06 1 2.77754999999995e-06 0 2.77799999999995e-06 0 2.77804999999995e-06 0 2.78199999999995e-06 0 2.78209999999995e-06 1 2.78349999999995e-06 1 2.78354999999995e-06 0 2.78399999999995e-06 0 2.78404999999995e-06 0 2.78799999999995e-06 0 2.78809999999995e-06 1 2.78949999999995e-06 1 2.78954999999995e-06 0 2.78999999999995e-06 0 2.79004999999995e-06 0 2.79399999999995e-06 0 2.79409999999995e-06 1 2.79549999999995e-06 1 2.79554999999995e-06 0 2.79599999999995e-06 0 2.79604999999995e-06 0 2.79999999999995e-06 0 2.80009999999995e-06 1 2.80149999999995e-06 1 2.80154999999995e-06 0 2.80199999999995e-06 0 2.80204999999995e-06 0 2.80599999999995e-06 0 2.80609999999995e-06 1 2.80749999999995e-06 1 2.80754999999995e-06 0 2.80799999999995e-06 0 2.80804999999995e-06 0 2.81199999999995e-06 0 2.81209999999995e-06 1 2.81349999999995e-06 1 2.81354999999995e-06 0 2.81399999999995e-06 0 2.81404999999995e-06 0 2.81799999999995e-06 0 2.81809999999995e-06 1 2.81949999999995e-06 1 2.81954999999995e-06 0 2.81999999999995e-06 0 2.82004999999995e-06 0 2.82399999999995e-06 0 2.82409999999995e-06 1 2.82549999999995e-06 1 2.82554999999995e-06 0 2.82599999999995e-06 0 2.82604999999995e-06 0 2.82999999999994e-06 0 2.83009999999994e-06 1 2.83149999999994e-06 1 2.83154999999994e-06 0 2.83199999999994e-06 0 2.83204999999994e-06 0 2.83599999999994e-06 0 2.83609999999994e-06 1 2.83749999999994e-06 1 2.83754999999994e-06 0 2.83799999999994e-06 0 2.83804999999994e-06 0 2.84199999999994e-06 0 2.84209999999994e-06 1 2.84349999999994e-06 1 2.84354999999994e-06 0 2.84399999999994e-06 0 2.84404999999994e-06 0 2.84799999999994e-06 0 2.84809999999994e-06 1 2.84949999999994e-06 1 2.84954999999994e-06 0 2.84999999999994e-06 0 2.85004999999994e-06 0 2.85399999999994e-06 0 2.85409999999994e-06 1 2.85549999999994e-06 1 2.85554999999994e-06 0 2.85599999999994e-06 0 2.85604999999994e-06 0 2.85999999999994e-06 0 2.86009999999994e-06 1 2.86149999999994e-06 1 2.86154999999994e-06 0 2.86199999999994e-06 0 2.86204999999994e-06 0 2.86599999999994e-06 0 2.86609999999994e-06 1 2.86749999999994e-06 1 2.86754999999994e-06 0 2.86799999999994e-06 0 2.86804999999994e-06 0 2.87199999999994e-06 0 2.87209999999994e-06 1 2.87349999999994e-06 1 2.87354999999994e-06 0 2.87399999999994e-06 0 2.87404999999994e-06 0 2.87799999999994e-06 0 2.87809999999994e-06 1 2.87949999999994e-06 1 2.87954999999994e-06 0 2.87999999999994e-06 0 2.88004999999994e-06 0 2.88399999999994e-06 0 2.88409999999994e-06 1 2.88549999999994e-06 1 2.88554999999994e-06 0 2.88599999999994e-06 0 2.88604999999994e-06 0 2.88999999999994e-06 0 2.89009999999994e-06 1 2.89149999999994e-06 1 2.89154999999994e-06 0 2.89199999999994e-06 0 2.89204999999994e-06 0 2.89599999999994e-06 0 2.89609999999994e-06 1 2.89749999999994e-06 1 2.89754999999994e-06 0 2.89799999999994e-06 0 2.89804999999994e-06 0 2.90199999999994e-06 0 2.90209999999994e-06 1 2.90349999999994e-06 1 2.90354999999994e-06 0 2.90399999999994e-06 0 2.90404999999994e-06 0 2.90799999999994e-06 0 2.90809999999994e-06 1 2.90949999999994e-06 1 2.90954999999994e-06 0 2.90999999999994e-06 0 2.91004999999994e-06 0 2.91399999999994e-06 0 2.91409999999994e-06 1 2.91549999999994e-06 1 2.91554999999994e-06 0 2.91599999999994e-06 0 2.91604999999994e-06 0 2.91999999999994e-06 0 2.92009999999994e-06 1 2.92149999999994e-06 1 2.92154999999994e-06 0 2.92199999999994e-06 0 2.92204999999994e-06 0 2.92599999999994e-06 0 2.92609999999994e-06 1 2.92749999999994e-06 1 2.92754999999994e-06 0 2.92799999999994e-06 0 2.92804999999994e-06 0 2.93199999999994e-06 0 2.93209999999994e-06 1 2.93349999999994e-06 1 2.93354999999994e-06 0 2.93399999999994e-06 0 2.93404999999994e-06 0 2.93799999999994e-06 0 2.93809999999994e-06 1 2.93949999999994e-06 1 2.93954999999994e-06 0 2.93999999999994e-06 0 2.94004999999994e-06 0 2.94399999999994e-06 0 2.94409999999994e-06 1 2.94549999999994e-06 1 2.94554999999994e-06 0 2.94599999999994e-06 0 2.94604999999994e-06 0 2.94999999999994e-06 0 2.95009999999994e-06 1 2.95149999999994e-06 1 2.95154999999994e-06 0 2.95199999999994e-06 0 2.95204999999994e-06 0 2.95599999999994e-06 0 2.95609999999994e-06 1 2.95749999999994e-06 1 2.95754999999994e-06 0 2.95799999999994e-06 0 2.95804999999994e-06 0 2.96199999999994e-06 0 2.96209999999994e-06 1 2.96349999999994e-06 1 2.96354999999994e-06 0 2.96399999999994e-06 0 2.96404999999994e-06 0 2.96799999999994e-06 0 2.96809999999994e-06 1 2.96949999999994e-06 1 2.96954999999994e-06 0 2.96999999999994e-06 0 2.97004999999994e-06 0 2.97399999999994e-06 0 2.97409999999994e-06 1 2.97549999999994e-06 1 2.97554999999994e-06 0 2.97599999999994e-06 0 2.97604999999994e-06 0 2.97999999999994e-06 0 2.98009999999993e-06 1 2.98149999999993e-06 1 2.98154999999994e-06 0 2.98199999999993e-06 0 2.98204999999993e-06 0 2.98599999999993e-06 0 2.98609999999993e-06 1 2.98749999999993e-06 1 2.98754999999993e-06 0 2.98799999999993e-06 0 2.98804999999993e-06 0 2.99199999999993e-06 0 2.99209999999993e-06 1 2.99349999999993e-06 1 2.99354999999993e-06 0 2.99399999999993e-06 0 2.99404999999993e-06 0 2.99799999999993e-06 0 2.99809999999993e-06 1 2.99949999999993e-06 1 2.99954999999993e-06 0 2.99999999999993e-06 0 3.00004999999993e-06 0 3.00399999999993e-06 0 3.00409999999993e-06 1 3.00549999999993e-06 1 3.00554999999993e-06 0 3.00599999999993e-06 0 3.00604999999993e-06 0 3.00999999999993e-06 0 3.01009999999993e-06 1 3.01149999999993e-06 1 3.01154999999993e-06 0 3.01199999999993e-06 0 3.01204999999993e-06 0 3.01599999999993e-06 0 3.01609999999993e-06 1 3.01749999999993e-06 1 3.01754999999993e-06 0 3.01799999999993e-06 0 3.01804999999993e-06 0 3.02199999999993e-06 0 3.02209999999993e-06 1 3.02349999999993e-06 1 3.02354999999993e-06 0 3.02399999999993e-06 0 3.02404999999993e-06 0 3.02799999999993e-06 0 3.02809999999993e-06 1 3.02949999999993e-06 1 3.02954999999993e-06 0 3.02999999999993e-06 0 3.03004999999993e-06 0 3.03399999999993e-06 0 3.03409999999993e-06 1 3.03549999999993e-06 1 3.03554999999993e-06 0 3.03599999999993e-06 0 3.03604999999993e-06 0 3.03999999999993e-06 0 3.04009999999993e-06 1 3.04149999999993e-06 1 3.04154999999993e-06 0 3.04199999999993e-06 0 3.04204999999993e-06 0 3.04599999999993e-06 0 3.04609999999993e-06 1 3.04749999999993e-06 1 3.04754999999993e-06 0 3.04799999999993e-06 0 3.04804999999993e-06 0 3.05199999999993e-06 0 3.05209999999993e-06 1 3.05349999999993e-06 1 3.05354999999993e-06 0 3.05399999999993e-06 0 3.05404999999993e-06 0 3.05799999999993e-06 0 3.05809999999993e-06 1 3.05949999999993e-06 1 3.05954999999993e-06 0 3.05999999999993e-06 0 3.06004999999993e-06 0 3.06399999999993e-06 0 3.06409999999993e-06 1 3.06549999999993e-06 1 3.06554999999993e-06 0 3.06599999999993e-06 0 3.06604999999993e-06 0 3.06999999999993e-06 0 3.07009999999993e-06 1 3.07149999999993e-06 1 3.07154999999993e-06 0 3.07699999999993e-06 0]
parameters wave_SAP = [0 1 4e-09 1 4.05e-09 0 6e-09 0 6.1e-09 1 1e-08 1 1.005e-08 0 1.2e-08 0 1.21e-08 1 1.6e-08 1 1.605e-08 0 1.8e-08 0 1.81e-08 1 2.2e-08 1 2.205e-08 0 2.4e-08 0 2.41e-08 1 2.8e-08 1 2.805e-08 0 3e-08 0 3.01e-08 1 3.4e-08 1 3.405e-08 0 3.6e-08 0 3.61e-08 1 4e-08 1 4.005e-08 0 4.2e-08 0 4.21e-08 1 4.6e-08 1 4.605e-08 0 4.8e-08 0 4.81e-08 1 5.2e-08 1 5.205e-08 0 5.4e-08 0 5.41e-08 1 5.8e-08 1 5.805e-08 0 6e-08 0 6.01e-08 1 6.4e-08 1 6.405e-08 0 6.6e-08 0 6.61e-08 1 7e-08 1 7.005e-08 0 7.2e-08 0 7.21e-08 1 7.6e-08 1 7.605e-08 0 7.8e-08 0 7.81e-08 1 8.2e-08 1 8.205e-08 0 8.4e-08 0 8.41e-08 1 8.8e-08 1 8.805e-08 0 9e-08 0 9.01e-08 1 9.4e-08 1 9.405e-08 0 9.6e-08 0 9.61e-08 1 1e-07 1 1.0005e-07 0 1.02e-07 0 1.021e-07 1 1.06e-07 1 1.0605e-07 0 1.08e-07 0 1.081e-07 1 1.12e-07 1 1.1205e-07 0 1.14e-07 0 1.141e-07 1 1.18e-07 1 1.1805e-07 0 1.2e-07 0 1.201e-07 1 1.24e-07 1 1.2405e-07 0 1.26e-07 0 1.261e-07 1 1.3e-07 1 1.3005e-07 0 1.32e-07 0 1.321e-07 1 1.36e-07 1 1.3605e-07 0 1.38e-07 0 1.381e-07 1 1.42e-07 1 1.4205e-07 0 1.44e-07 0 1.441e-07 1 1.48e-07 1 1.4805e-07 0 1.5e-07 0 1.501e-07 1 1.54e-07 1 1.5405e-07 0 1.56e-07 0 1.561e-07 1 1.6e-07 1 1.6005e-07 0 1.62e-07 0 1.621e-07 1 1.66e-07 1 1.6605e-07 0 1.68e-07 0 1.681e-07 1 1.72e-07 1 1.7205e-07 0 1.74e-07 0 1.741e-07 1 1.78e-07 1 1.7805e-07 0 1.8e-07 0 1.801e-07 1 1.84e-07 1 1.8405e-07 0 1.86e-07 0 1.861e-07 1 1.9e-07 1 1.9005e-07 0 1.92e-07 0 1.921e-07 1 1.96e-07 1 1.9605e-07 0 1.98e-07 0 1.981e-07 1 2.02e-07 1 2.0205e-07 0 2.04e-07 0 2.041e-07 1 2.08e-07 1 2.0805e-07 0 2.1e-07 0 2.101e-07 1 2.14e-07 1 2.1405e-07 0 2.16e-07 0 2.161e-07 1 2.2e-07 1 2.2005e-07 0 2.22e-07 0 2.221e-07 1 2.26e-07 1 2.2605e-07 0 2.28000000000001e-07 0 2.28100000000001e-07 1 2.32000000000001e-07 1 2.32050000000001e-07 0 2.34000000000001e-07 0 2.34100000000001e-07 1 2.38000000000001e-07 1 2.38050000000001e-07 0 2.40000000000001e-07 0 2.40100000000001e-07 1 2.44e-07 1 2.4405e-07 0 2.46e-07 0 2.461e-07 1 2.5e-07 1 2.5005e-07 0 2.52e-07 0 2.521e-07 1 2.56e-07 1 2.5605e-07 0 2.58e-07 0 2.581e-07 1 2.62e-07 1 2.6205e-07 0 2.64e-07 0 2.641e-07 1 2.68e-07 1 2.6805e-07 0 2.7e-07 0 2.701e-07 1 2.74e-07 1 2.7405e-07 0 2.76e-07 0 2.761e-07 1 2.8e-07 1 2.8005e-07 0 2.82e-07 0 2.821e-07 1 2.86e-07 1 2.8605e-07 0 2.88e-07 0 2.881e-07 1 2.92e-07 1 2.9205e-07 0 2.94e-07 0 2.941e-07 1 2.98e-07 1 2.9805e-07 0 3e-07 0 3.001e-07 1 3.04e-07 1 3.0405e-07 0 3.06e-07 0 3.061e-07 1 3.1e-07 1 3.1005e-07 0 3.12e-07 0 3.121e-07 1 3.16e-07 1 3.1605e-07 0 3.18e-07 0 3.181e-07 1 3.22e-07 1 3.2205e-07 0 3.24e-07 0 3.241e-07 1 3.28e-07 1 3.2805e-07 0 3.3e-07 0 3.301e-07 1 3.34e-07 1 3.3405e-07 0 3.36e-07 0 3.361e-07 1 3.4e-07 1 3.4005e-07 0 3.42e-07 0 3.421e-07 1 3.46e-07 1 3.4605e-07 0 3.48e-07 0 3.481e-07 1 3.52e-07 1 3.5205e-07 0 3.54e-07 0 3.541e-07 1 3.58e-07 1 3.5805e-07 0 3.6e-07 0 3.601e-07 1 3.64e-07 1 3.6405e-07 0 3.66e-07 0 3.661e-07 1 3.7e-07 1 3.7005e-07 0 3.72e-07 0 3.721e-07 1 3.76e-07 1 3.7605e-07 0 3.78e-07 0 3.781e-07 1 3.82e-07 1 3.8205e-07 0 3.84e-07 0 3.841e-07 1 3.88e-07 1 3.8805e-07 0 3.9e-07 0 3.901e-07 1 3.94e-07 1 3.9405e-07 0 3.96e-07 0 3.961e-07 1 4e-07 1 4.0005e-07 0 4.02e-07 0 4.021e-07 1 4.06e-07 1 4.0605e-07 0 4.08e-07 0 4.081e-07 1 4.12e-07 1 4.1205e-07 0 4.14e-07 0 4.141e-07 1 4.18e-07 1 4.1805e-07 0 4.2e-07 0 4.201e-07 1 4.24e-07 1 4.2405e-07 0 4.26e-07 0 4.261e-07 1 4.3e-07 1 4.3005e-07 0 4.32e-07 0 4.321e-07 1 4.36e-07 1 4.3605e-07 0 4.38e-07 0 4.381e-07 1 4.42e-07 1 4.4205e-07 0 4.44e-07 0 4.441e-07 1 4.48e-07 1 4.4805e-07 0 4.5e-07 0 4.501e-07 1 4.54e-07 1 4.5405e-07 0 4.56e-07 0 4.561e-07 1 4.6e-07 1 4.6005e-07 0 4.62e-07 0 4.621e-07 1 4.66e-07 1 4.6605e-07 0 4.68e-07 0 4.681e-07 1 4.72e-07 1 4.7205e-07 0 4.74e-07 0 4.741e-07 1 4.77999999999999e-07 1 4.78049999999999e-07 0 4.8e-07 0 4.801e-07 1 4.84e-07 1 4.8405e-07 0 4.86e-07 0 4.861e-07 1 4.9e-07 1 4.9005e-07 0 4.92e-07 0 4.921e-07 1 4.96e-07 1 4.9605e-07 0 4.98e-07 0 4.981e-07 1 5.02e-07 1 5.0205e-07 0 5.04e-07 0 5.041e-07 1 5.08e-07 1 5.0805e-07 0 5.1e-07 0 5.101e-07 1 5.14e-07 1 5.1405e-07 0 5.16e-07 0 5.161e-07 1 5.2e-07 1 5.2005e-07 0 5.22e-07 0 5.221e-07 1 5.26e-07 1 5.2605e-07 0 5.28e-07 0 5.281e-07 1 5.32e-07 1 5.3205e-07 0 5.34e-07 0 5.341e-07 1 5.38e-07 1 5.3805e-07 0 5.4e-07 0 5.401e-07 1 5.44e-07 1 5.4405e-07 0 5.46e-07 0 5.461e-07 1 5.5e-07 1 5.5005e-07 0 5.52e-07 0 5.521e-07 1 5.56e-07 1 5.5605e-07 0 5.58e-07 0 5.581e-07 1 5.62e-07 1 5.6205e-07 0 5.64e-07 0 5.641e-07 1 5.68e-07 1 5.6805e-07 0 5.7e-07 0 5.701e-07 1 5.74e-07 1 5.7405e-07 0 5.76e-07 0 5.761e-07 1 5.8e-07 1 5.8005e-07 0 5.82e-07 0 5.821e-07 1 5.86e-07 1 5.8605e-07 0 5.88e-07 0 5.881e-07 1 5.92e-07 1 5.9205e-07 0 5.94e-07 0 5.941e-07 1 5.98e-07 1 5.9805e-07 0 6e-07 0 6.001e-07 1 6.04e-07 1 6.0405e-07 0 6.06e-07 0 6.061e-07 1 6.1e-07 1 6.1005e-07 0 6.12e-07 0 6.121e-07 1 6.16e-07 1 6.1605e-07 0 6.18e-07 0 6.181e-07 1 6.22e-07 1 6.2205e-07 0 6.24e-07 0 6.241e-07 1 6.28e-07 1 6.2805e-07 0 6.3e-07 0 6.301e-07 1 6.34e-07 1 6.3405e-07 0 6.36e-07 0 6.361e-07 1 6.4e-07 1 6.4005e-07 0 6.42e-07 0 6.421e-07 1 6.46e-07 1 6.4605e-07 0 6.48e-07 0 6.481e-07 1 6.52e-07 1 6.5205e-07 0 6.54e-07 0 6.541e-07 1 6.58e-07 1 6.5805e-07 0 6.6e-07 0 6.601e-07 1 6.64e-07 1 6.6405e-07 0 6.66e-07 0 6.661e-07 1 6.7e-07 1 6.7005e-07 0 6.72e-07 0 6.721e-07 1 6.76e-07 1 6.7605e-07 0 6.78e-07 0 6.781e-07 1 6.82e-07 1 6.8205e-07 0 6.84e-07 0 6.841e-07 1 6.88e-07 1 6.8805e-07 0 6.9e-07 0 6.901e-07 1 6.94e-07 1 6.9405e-07 0 6.96000000000001e-07 0 6.96100000000001e-07 1 7e-07 1 7.00050000000001e-07 0 7.02000000000001e-07 0 7.02100000000001e-07 1 7.06000000000001e-07 1 7.06050000000001e-07 0 7.08000000000001e-07 0 7.08100000000001e-07 1 7.12000000000001e-07 1 7.12050000000001e-07 0 7.14000000000001e-07 0 7.14100000000001e-07 1 7.18000000000001e-07 1 7.18050000000001e-07 0 7.20000000000001e-07 0 7.20100000000001e-07 1 7.24000000000001e-07 1 7.24050000000001e-07 0 7.26000000000001e-07 0 7.26100000000001e-07 1 7.30000000000001e-07 1 7.30050000000001e-07 0 7.32000000000001e-07 0 7.32100000000001e-07 1 7.36000000000001e-07 1 7.36050000000001e-07 0 7.38000000000001e-07 0 7.38100000000001e-07 1 7.42000000000001e-07 1 7.42050000000001e-07 0 7.44000000000001e-07 0 7.44100000000001e-07 1 7.48000000000001e-07 1 7.48050000000001e-07 0 7.50000000000001e-07 0 7.50100000000001e-07 1 7.54000000000001e-07 1 7.54050000000001e-07 0 7.56000000000001e-07 0 7.56100000000001e-07 1 7.60000000000001e-07 1 7.60050000000001e-07 0 7.62000000000001e-07 0 7.62100000000001e-07 1 7.66000000000001e-07 1 7.66050000000001e-07 0 7.68000000000001e-07 0 7.68100000000001e-07 1 7.72000000000001e-07 1 7.72050000000001e-07 0 7.74000000000001e-07 0 7.74100000000001e-07 1 7.78000000000001e-07 1 7.78050000000001e-07 0 7.80000000000001e-07 0 7.80100000000001e-07 1 7.84000000000001e-07 1 7.84050000000001e-07 0 7.86000000000001e-07 0 7.86100000000001e-07 1 7.90000000000001e-07 1 7.90050000000001e-07 0 7.92000000000001e-07 0 7.92100000000001e-07 1 7.96000000000001e-07 1 7.96050000000001e-07 0 7.98000000000001e-07 0 7.98100000000001e-07 1 8.02000000000001e-07 1 8.02050000000001e-07 0 8.04000000000001e-07 0 8.04100000000001e-07 1 8.08000000000001e-07 1 8.08050000000001e-07 0 8.10000000000001e-07 0 8.10100000000001e-07 1 8.14000000000001e-07 1 8.14050000000001e-07 0 8.16000000000001e-07 0 8.16100000000001e-07 1 8.20000000000001e-07 1 8.20050000000001e-07 0 8.22000000000001e-07 0 8.22100000000001e-07 1 8.26000000000001e-07 1 8.26050000000001e-07 0 8.28000000000001e-07 0 8.28100000000001e-07 1 8.32000000000001e-07 1 8.32050000000001e-07 0 8.34000000000001e-07 0 8.34100000000001e-07 1 8.38000000000001e-07 1 8.38050000000001e-07 0 8.40000000000001e-07 0 8.40100000000001e-07 1 8.44000000000001e-07 1 8.44050000000001e-07 0 8.46000000000001e-07 0 8.46100000000001e-07 1 8.50000000000001e-07 1 8.50050000000001e-07 0 8.52000000000001e-07 0 8.52100000000001e-07 1 8.56000000000001e-07 1 8.56050000000001e-07 0 8.58000000000001e-07 0 8.58100000000001e-07 1 8.62000000000001e-07 1 8.62050000000001e-07 0 8.64000000000001e-07 0 8.64100000000001e-07 1 8.68000000000001e-07 1 8.68050000000001e-07 0 8.70000000000001e-07 0 8.70100000000001e-07 1 8.74000000000001e-07 1 8.74050000000001e-07 0 8.76000000000001e-07 0 8.76100000000001e-07 1 8.80000000000001e-07 1 8.80050000000001e-07 0 8.82000000000001e-07 0 8.82100000000001e-07 1 8.86000000000001e-07 1 8.86050000000001e-07 0 8.88000000000001e-07 0 8.88100000000001e-07 1 8.92000000000001e-07 1 8.92050000000001e-07 0 8.94000000000001e-07 0 8.94100000000001e-07 1 8.98000000000001e-07 1 8.98050000000001e-07 0 9.00000000000001e-07 0 9.00100000000001e-07 1 9.04000000000001e-07 1 9.04050000000001e-07 0 9.06000000000001e-07 0 9.06100000000001e-07 1 9.10000000000001e-07 1 9.10050000000001e-07 0 9.12000000000001e-07 0 9.12100000000002e-07 1 9.16000000000001e-07 1 9.16050000000001e-07 0 9.18000000000002e-07 0 9.18100000000002e-07 1 9.22000000000002e-07 1 9.22050000000002e-07 0 9.24000000000002e-07 0 9.24100000000002e-07 1 9.28000000000002e-07 1 9.28050000000002e-07 0 9.30000000000002e-07 0 9.30100000000002e-07 1 9.34000000000002e-07 1 9.34050000000002e-07 0 9.36000000000002e-07 0 9.36100000000002e-07 1 9.40000000000002e-07 1 9.40050000000002e-07 0 9.42000000000002e-07 0 9.42100000000002e-07 1 9.46000000000002e-07 1 9.46050000000002e-07 0 9.48000000000002e-07 0 9.48100000000002e-07 1 9.52000000000002e-07 1 9.52050000000002e-07 0 9.54000000000002e-07 0 9.54100000000002e-07 1 9.58000000000002e-07 1 9.58050000000002e-07 0 9.60000000000002e-07 0 9.60100000000002e-07 1 9.64000000000002e-07 1 9.64050000000002e-07 0 9.66000000000002e-07 0 9.66100000000002e-07 1 9.70000000000002e-07 1 9.70050000000002e-07 0 9.72000000000002e-07 0 9.72100000000002e-07 1 9.76000000000002e-07 1 9.76050000000002e-07 0 9.78000000000002e-07 0 9.78100000000002e-07 1 9.82000000000002e-07 1 9.82050000000002e-07 0 9.84000000000002e-07 0 9.84100000000002e-07 1 9.88000000000002e-07 1 9.88050000000002e-07 0 9.90000000000002e-07 0 9.90100000000002e-07 1 9.94000000000002e-07 1 9.94050000000002e-07 0 9.96000000000002e-07 0 9.96100000000002e-07 1 1e-06 1 1.00005e-06 0 1.002e-06 0 1.0021e-06 1 1.006e-06 1 1.00605e-06 0 1.008e-06 0 1.0081e-06 1 1.012e-06 1 1.01205e-06 0 1.014e-06 0 1.0141e-06 1 1.018e-06 1 1.01805e-06 0 1.02e-06 0 1.0201e-06 1 1.024e-06 1 1.02405e-06 0 1.026e-06 0 1.0261e-06 1 1.03e-06 1 1.03005e-06 0 1.032e-06 0 1.0321e-06 1 1.036e-06 1 1.03605e-06 0 1.038e-06 0 1.0381e-06 1 1.042e-06 1 1.04205e-06 0 1.044e-06 0 1.0441e-06 1 1.048e-06 1 1.04805e-06 0 1.05e-06 0 1.0501e-06 1 1.054e-06 1 1.05405e-06 0 1.056e-06 0 1.0561e-06 1 1.06e-06 1 1.06005e-06 0 1.062e-06 0 1.0621e-06 1 1.066e-06 1 1.06605e-06 0 1.068e-06 0 1.0681e-06 1 1.072e-06 1 1.07205e-06 0 1.074e-06 0 1.0741e-06 1 1.078e-06 1 1.07805e-06 0 1.08e-06 0 1.0801e-06 1 1.084e-06 1 1.08405e-06 0 1.086e-06 0 1.0861e-06 1 1.09e-06 1 1.09005e-06 0 1.092e-06 0 1.0921e-06 1 1.096e-06 1 1.09605e-06 0 1.098e-06 0 1.0981e-06 1 1.102e-06 1 1.10205e-06 0 1.104e-06 0 1.1041e-06 1 1.108e-06 1 1.10805e-06 0 1.11e-06 0 1.1101e-06 1 1.114e-06 1 1.11405e-06 0 1.116e-06 0 1.1161e-06 1 1.12e-06 1 1.12005e-06 0 1.122e-06 0 1.1221e-06 1 1.126e-06 1 1.12605e-06 0 1.128e-06 0 1.1281e-06 1 1.132e-06 1 1.13205e-06 0 1.134e-06 0 1.1341e-06 1 1.138e-06 1 1.13805e-06 0 1.14e-06 0 1.1401e-06 1 1.144e-06 1 1.14405e-06 0 1.146e-06 0 1.1461e-06 1 1.15e-06 1 1.15005e-06 0 1.152e-06 0 1.1521e-06 1 1.156e-06 1 1.15605e-06 0 1.158e-06 0 1.1581e-06 1 1.162e-06 1 1.16205e-06 0 1.164e-06 0 1.1641e-06 1 1.168e-06 1 1.16805e-06 0 1.17e-06 0 1.1701e-06 1 1.174e-06 1 1.17405e-06 0 1.176e-06 0 1.1761e-06 1 1.18e-06 1 1.18005e-06 0 1.182e-06 0 1.1821e-06 1 1.186e-06 1 1.18605e-06 0 1.188e-06 0 1.1881e-06 1 1.192e-06 1 1.19205e-06 0 1.194e-06 0 1.1941e-06 1 1.198e-06 1 1.19805e-06 0 1.2e-06 0 1.2001e-06 1 1.204e-06 1 1.20405e-06 0 1.206e-06 0 1.2061e-06 1 1.21e-06 1 1.21005e-06 0 1.212e-06 0 1.2121e-06 1 1.216e-06 1 1.21605e-06 0 1.218e-06 0 1.2181e-06 1 1.222e-06 1 1.22205e-06 0 1.224e-06 0 1.2241e-06 1 1.228e-06 1 1.22805e-06 0 1.23e-06 0 1.2301e-06 1 1.234e-06 1 1.23405e-06 0 1.236e-06 0 1.2361e-06 1 1.24e-06 1 1.24005e-06 0 1.242e-06 0 1.2421e-06 1 1.246e-06 1 1.24605e-06 0 1.248e-06 0 1.2481e-06 1 1.252e-06 1 1.25205e-06 0 1.254e-06 0 1.2541e-06 1 1.258e-06 1 1.25805e-06 0 1.26e-06 0 1.2601e-06 1 1.264e-06 1 1.26405e-06 0 1.266e-06 0 1.2661e-06 1 1.27e-06 1 1.27005e-06 0 1.272e-06 0 1.2721e-06 1 1.276e-06 1 1.27605e-06 0 1.278e-06 0 1.2781e-06 1 1.282e-06 1 1.28205e-06 0 1.284e-06 0 1.2841e-06 1 1.288e-06 1 1.28805e-06 0 1.29e-06 0 1.2901e-06 1 1.294e-06 1 1.29405e-06 0 1.296e-06 0 1.2961e-06 1 1.3e-06 1 1.30005e-06 0 1.302e-06 0 1.3021e-06 1 1.306e-06 1 1.30605e-06 0 1.308e-06 0 1.3081e-06 1 1.312e-06 1 1.31205e-06 0 1.314e-06 0 1.3141e-06 1 1.318e-06 1 1.31805e-06 0 1.32e-06 0 1.3201e-06 1 1.324e-06 1 1.32405e-06 0 1.326e-06 0 1.3261e-06 1 1.33e-06 1 1.33005e-06 0 1.332e-06 0 1.3321e-06 1 1.336e-06 1 1.33605e-06 0 1.338e-06 0 1.3381e-06 1 1.342e-06 1 1.34205e-06 0 1.344e-06 0 1.3441e-06 1 1.348e-06 1 1.34805e-06 0 1.35e-06 0 1.3501e-06 1 1.354e-06 1 1.35405e-06 0 1.356e-06 0 1.3561e-06 1 1.36e-06 1 1.36005e-06 0 1.362e-06 0 1.3621e-06 1 1.366e-06 1 1.36605e-06 0 1.368e-06 0 1.3681e-06 1 1.372e-06 1 1.37205e-06 0 1.374e-06 0 1.3741e-06 1 1.378e-06 1 1.37805e-06 0 1.38e-06 0 1.3801e-06 1 1.384e-06 1 1.38405e-06 0 1.386e-06 0 1.3861e-06 1 1.39e-06 1 1.39005e-06 0 1.392e-06 0 1.3921e-06 1 1.396e-06 1 1.39605e-06 0 1.398e-06 0 1.3981e-06 1 1.402e-06 1 1.40205e-06 0 1.404e-06 0 1.4041e-06 1 1.408e-06 1 1.40805e-06 0 1.41e-06 0 1.4101e-06 1 1.414e-06 1 1.41405e-06 0 1.416e-06 0 1.4161e-06 1 1.42e-06 1 1.42005e-06 0 1.422e-06 0 1.4221e-06 1 1.426e-06 1 1.42605e-06 0 1.428e-06 0 1.4281e-06 1 1.432e-06 1 1.43205e-06 0 1.434e-06 0 1.4341e-06 1 1.438e-06 1 1.43805e-06 0 1.44e-06 0 1.4401e-06 1 1.444e-06 1 1.44405e-06 0 1.446e-06 0 1.4461e-06 1 1.45e-06 1 1.45005e-06 0 1.452e-06 0 1.4521e-06 1 1.456e-06 1 1.45605e-06 0 1.458e-06 0 1.4581e-06 1 1.462e-06 1 1.46205e-06 0 1.464e-06 0 1.4641e-06 1 1.468e-06 1 1.46805e-06 0 1.47e-06 0 1.4701e-06 1 1.474e-06 1 1.47405e-06 0 1.476e-06 0 1.4761e-06 1 1.48e-06 1 1.48005e-06 0 1.482e-06 0 1.4821e-06 1 1.486e-06 1 1.48605e-06 0 1.488e-06 0 1.4881e-06 1 1.492e-06 1 1.49205e-06 0 1.494e-06 0 1.4941e-06 1 1.498e-06 1 1.49805e-06 0 1.5e-06 0 1.5001e-06 1 1.504e-06 1 1.50405e-06 0 1.506e-06 0 1.5061e-06 1 1.51e-06 1 1.51005e-06 0 1.512e-06 0 1.5121e-06 1 1.516e-06 1 1.51605e-06 0 1.518e-06 0 1.5181e-06 1 1.522e-06 1 1.52205e-06 0 1.524e-06 0 1.5241e-06 1 1.528e-06 1 1.52805e-06 0 1.53e-06 0 1.5301e-06 1 1.534e-06 1 1.53405e-06 0 1.536e-06 0 1.5361e-06 1 1.54e-06 1 1.54005e-06 0 1.542e-06 0 1.5421e-06 1 1.546e-06 1 1.54605e-06 0 1.548e-06 0 1.5481e-06 1 1.552e-06 1 1.55205e-06 0 1.554e-06 0 1.5541e-06 1 1.558e-06 1 1.55805e-06 0 1.56e-06 0 1.5601e-06 1 1.564e-06 1 1.56405e-06 0 1.566e-06 0 1.5661e-06 1 1.57e-06 1 1.57005e-06 0 1.572e-06 0 1.5721e-06 1 1.576e-06 1 1.57605e-06 0 1.578e-06 0 1.5781e-06 1 1.582e-06 1 1.58205e-06 0 1.584e-06 0 1.5841e-06 1 1.588e-06 1 1.58805e-06 0 1.59e-06 0 1.5901e-06 1 1.594e-06 1 1.59405e-06 0 1.596e-06 0 1.5961e-06 1 1.6e-06 1 1.60005e-06 0 1.602e-06 0 1.6021e-06 1 1.606e-06 1 1.60605e-06 0 1.608e-06 0 1.6081e-06 1 1.612e-06 1 1.61205e-06 0 1.614e-06 0 1.6141e-06 1 1.618e-06 1 1.61805e-06 0 1.62e-06 0 1.6201e-06 1 1.624e-06 1 1.62405e-06 0 1.626e-06 0 1.6261e-06 1 1.63e-06 1 1.63005e-06 0 1.632e-06 0 1.6321e-06 1 1.636e-06 1 1.63605e-06 0 1.638e-06 0 1.6381e-06 1 1.642e-06 1 1.64205e-06 0 1.644e-06 0 1.6441e-06 1 1.648e-06 1 1.64805e-06 0 1.65e-06 0 1.6501e-06 1 1.654e-06 1 1.65405e-06 0 1.656e-06 0 1.6561e-06 1 1.66e-06 1 1.66005e-06 0 1.662e-06 0 1.6621e-06 1 1.666e-06 1 1.66605e-06 0 1.668e-06 0 1.6681e-06 1 1.672e-06 1 1.67205e-06 0 1.674e-06 0 1.6741e-06 1 1.678e-06 1 1.67805e-06 0 1.68e-06 0 1.6801e-06 1 1.684e-06 1 1.68405e-06 0 1.686e-06 0 1.6861e-06 1 1.69e-06 1 1.69005e-06 0 1.692e-06 0 1.6921e-06 1 1.69600000000001e-06 1 1.69605e-06 0 1.698e-06 0 1.6981e-06 1 1.70200000000001e-06 1 1.70205e-06 0 1.704e-06 0 1.7041e-06 1 1.70800000000001e-06 1 1.70805e-06 0 1.71000000000001e-06 0 1.71010000000001e-06 1 1.71400000000001e-06 1 1.71405000000001e-06 0 1.71600000000001e-06 0 1.71610000000001e-06 1 1.72000000000001e-06 1 1.72005000000001e-06 0 1.72200000000001e-06 0 1.72210000000001e-06 1 1.72600000000001e-06 1 1.72605000000001e-06 0 1.72800000000001e-06 0 1.72810000000001e-06 1 1.73200000000001e-06 1 1.73205000000001e-06 0 1.73400000000001e-06 0 1.73410000000001e-06 1 1.73800000000001e-06 1 1.73805000000001e-06 0 1.74000000000001e-06 0 1.74010000000001e-06 1 1.74400000000001e-06 1 1.74405000000001e-06 0 1.74600000000001e-06 0 1.74610000000001e-06 1 1.75000000000001e-06 1 1.75005000000001e-06 0 1.75200000000001e-06 0 1.75210000000001e-06 1 1.75600000000001e-06 1 1.75605000000001e-06 0 1.75800000000001e-06 0 1.75810000000001e-06 1 1.76200000000001e-06 1 1.76205000000001e-06 0 1.76400000000001e-06 0 1.76410000000001e-06 1 1.76800000000001e-06 1 1.76805000000001e-06 0 1.77000000000001e-06 0 1.77010000000001e-06 1 1.77400000000001e-06 1 1.77405000000001e-06 0 1.77600000000001e-06 0 1.77610000000001e-06 1 1.78000000000001e-06 1 1.78005000000001e-06 0 1.78200000000001e-06 0 1.78210000000001e-06 1 1.78600000000001e-06 1 1.78605000000001e-06 0 1.78800000000001e-06 0 1.78810000000001e-06 1 1.79200000000001e-06 1 1.79205000000001e-06 0 1.79400000000001e-06 0 1.79410000000001e-06 1 1.79800000000001e-06 1 1.79805000000001e-06 0 1.80000000000001e-06 0 1.80010000000001e-06 1 1.80400000000001e-06 1 1.80405000000001e-06 0 1.80600000000001e-06 0 1.80610000000001e-06 1 1.81000000000001e-06 1 1.81005000000001e-06 0 1.81200000000001e-06 0 1.81210000000001e-06 1 1.81600000000001e-06 1 1.81605000000001e-06 0 1.81800000000001e-06 0 1.81810000000001e-06 1 1.82200000000001e-06 1 1.82205000000001e-06 0 1.82400000000001e-06 0 1.82410000000001e-06 1 1.82800000000001e-06 1 1.82805000000001e-06 0 1.83000000000001e-06 0 1.83010000000001e-06 1 1.83400000000001e-06 1 1.83405000000001e-06 0 1.83600000000001e-06 0 1.83610000000001e-06 1 1.84000000000001e-06 1 1.84005000000001e-06 0 1.84200000000001e-06 0 1.84210000000001e-06 1 1.84600000000001e-06 1 1.84605000000001e-06 0 1.84800000000001e-06 0 1.84810000000001e-06 1 1.85200000000001e-06 1 1.85205000000001e-06 0 1.85400000000001e-06 0 1.85410000000001e-06 1 1.85800000000001e-06 1 1.85805000000001e-06 0 1.86000000000001e-06 0 1.86010000000001e-06 1 1.86400000000001e-06 1 1.86405000000001e-06 0 1.86600000000001e-06 0 1.86610000000001e-06 1 1.87000000000001e-06 1 1.87005000000001e-06 0 1.87200000000001e-06 0 1.87210000000001e-06 1 1.87600000000001e-06 1 1.87605000000001e-06 0 1.87800000000001e-06 0 1.87810000000001e-06 1 1.88200000000001e-06 1 1.88205000000001e-06 0 1.88400000000001e-06 0 1.88410000000001e-06 1 1.88800000000001e-06 1 1.88805000000001e-06 0 1.89000000000001e-06 0 1.89010000000001e-06 1 1.89400000000001e-06 1 1.89405000000001e-06 0 1.89600000000001e-06 0 1.89610000000001e-06 1 1.90000000000001e-06 1 1.90005000000001e-06 0 1.90200000000001e-06 0 1.90210000000001e-06 1 1.90600000000001e-06 1 1.90605000000001e-06 0 1.90800000000001e-06 0 1.90810000000001e-06 1 1.91200000000001e-06 1 1.91205000000001e-06 0 1.91400000000001e-06 0 1.91410000000001e-06 1 1.91800000000001e-06 1 1.91805000000001e-06 0 1.92e-06 0 1.9201e-06 1 1.924e-06 1 1.92405e-06 0 1.926e-06 0 1.9261e-06 1 1.93e-06 1 1.93005e-06 0 1.932e-06 0 1.9321e-06 1 1.936e-06 1 1.93605e-06 0 1.938e-06 0 1.9381e-06 1 1.942e-06 1 1.94205e-06 0 1.944e-06 0 1.9441e-06 1 1.948e-06 1 1.94805e-06 0 1.95e-06 0 1.9501e-06 1 1.954e-06 1 1.95405e-06 0 1.956e-06 0 1.9561e-06 1 1.96e-06 1 1.96005e-06 0 1.962e-06 0 1.9621e-06 1 1.966e-06 1 1.96605e-06 0 1.968e-06 0 1.9681e-06 1 1.972e-06 1 1.97205e-06 0 1.974e-06 0 1.9741e-06 1 1.978e-06 1 1.97805e-06 0 1.98e-06 0 1.9801e-06 1 1.984e-06 1 1.98405e-06 0 1.986e-06 0 1.9861e-06 1 1.99e-06 1 1.99005e-06 0 1.992e-06 0 1.9921e-06 1 1.996e-06 1 1.99605e-06 0 1.998e-06 0 1.9981e-06 1 2.002e-06 1 2.00205e-06 0 2.004e-06 0 2.0041e-06 1 2.008e-06 1 2.00805e-06 0 2.01e-06 0 2.0101e-06 1 2.014e-06 1 2.01405e-06 0 2.016e-06 0 2.0161e-06 1 2.02e-06 1 2.02005e-06 0 2.022e-06 0 2.0221e-06 1 2.026e-06 1 2.02605e-06 0 2.028e-06 0 2.0281e-06 1 2.032e-06 1 2.03205e-06 0 2.034e-06 0 2.0341e-06 1 2.038e-06 1 2.03805e-06 0 2.04e-06 0 2.0401e-06 1 2.044e-06 1 2.04405e-06 0 2.046e-06 0 2.0461e-06 1 2.05e-06 1 2.05005e-06 0 2.052e-06 0 2.0521e-06 1 2.056e-06 1 2.05605e-06 0 2.058e-06 0 2.0581e-06 1 2.062e-06 1 2.06205e-06 0 2.064e-06 0 2.0641e-06 1 2.068e-06 1 2.06805e-06 0 2.07e-06 0 2.07009999999999e-06 1 2.07399999999999e-06 1 2.07404999999999e-06 0 2.07599999999999e-06 0 2.07609999999999e-06 1 2.07999999999999e-06 1 2.08004999999999e-06 0 2.08199999999999e-06 0 2.08209999999999e-06 1 2.08599999999999e-06 1 2.08604999999999e-06 0 2.08799999999999e-06 0 2.08809999999999e-06 1 2.09199999999999e-06 1 2.09204999999999e-06 0 2.09399999999999e-06 0 2.09409999999999e-06 1 2.09799999999999e-06 1 2.09804999999999e-06 0 2.09999999999999e-06 0 2.10009999999999e-06 1 2.10399999999999e-06 1 2.10404999999999e-06 0 2.10599999999999e-06 0 2.10609999999999e-06 1 2.10999999999999e-06 1 2.11004999999999e-06 0 2.11199999999999e-06 0 2.11209999999999e-06 1 2.11599999999999e-06 1 2.11604999999999e-06 0 2.11799999999999e-06 0 2.11809999999999e-06 1 2.12199999999999e-06 1 2.12204999999999e-06 0 2.12399999999999e-06 0 2.12409999999999e-06 1 2.12799999999999e-06 1 2.12804999999999e-06 0 2.12999999999999e-06 0 2.13009999999999e-06 1 2.13399999999999e-06 1 2.13404999999999e-06 0 2.13599999999999e-06 0 2.13609999999999e-06 1 2.13999999999999e-06 1 2.14004999999999e-06 0 2.14199999999999e-06 0 2.14209999999999e-06 1 2.14599999999999e-06 1 2.14604999999999e-06 0 2.14799999999999e-06 0 2.14809999999999e-06 1 2.15199999999999e-06 1 2.15204999999999e-06 0 2.15399999999999e-06 0 2.15409999999999e-06 1 2.15799999999999e-06 1 2.15804999999999e-06 0 2.15999999999999e-06 0 2.16009999999999e-06 1 2.16399999999999e-06 1 2.16404999999999e-06 0 2.16599999999999e-06 0 2.16609999999999e-06 1 2.16999999999999e-06 1 2.17004999999999e-06 0 2.17199999999999e-06 0 2.17209999999999e-06 1 2.17599999999999e-06 1 2.17604999999999e-06 0 2.17799999999999e-06 0 2.17809999999999e-06 1 2.18199999999999e-06 1 2.18204999999999e-06 0 2.18399999999999e-06 0 2.18409999999999e-06 1 2.18799999999999e-06 1 2.18804999999999e-06 0 2.18999999999999e-06 0 2.19009999999999e-06 1 2.19399999999999e-06 1 2.19404999999999e-06 0 2.19599999999999e-06 0 2.19609999999999e-06 1 2.19999999999999e-06 1 2.20004999999999e-06 0 2.20199999999999e-06 0 2.20209999999999e-06 1 2.20599999999999e-06 1 2.20604999999999e-06 0 2.20799999999999e-06 0 2.20809999999999e-06 1 2.21199999999999e-06 1 2.21204999999999e-06 0 2.21399999999999e-06 0 2.21409999999999e-06 1 2.21799999999999e-06 1 2.21804999999999e-06 0 2.21999999999999e-06 0 2.22009999999998e-06 1 2.22399999999998e-06 1 2.22404999999999e-06 0 2.22599999999998e-06 0 2.22609999999998e-06 1 2.22999999999998e-06 1 2.23004999999998e-06 0 2.23199999999998e-06 0 2.23209999999998e-06 1 2.23599999999998e-06 1 2.23604999999998e-06 0 2.23799999999998e-06 0 2.23809999999998e-06 1 2.24199999999998e-06 1 2.24204999999998e-06 0 2.24399999999998e-06 0 2.24409999999998e-06 1 2.24799999999998e-06 1 2.24804999999998e-06 0 2.24999999999998e-06 0 2.25009999999998e-06 1 2.25399999999998e-06 1 2.25404999999998e-06 0 2.25599999999998e-06 0 2.25609999999998e-06 1 2.25999999999998e-06 1 2.26004999999998e-06 0 2.26199999999998e-06 0 2.26209999999998e-06 1 2.26599999999998e-06 1 2.26604999999998e-06 0 2.26799999999998e-06 0 2.26809999999998e-06 1 2.27199999999998e-06 1 2.27204999999998e-06 0 2.27399999999998e-06 0 2.27409999999998e-06 1 2.27799999999998e-06 1 2.27804999999998e-06 0 2.27999999999998e-06 0 2.28009999999998e-06 1 2.28399999999998e-06 1 2.28404999999998e-06 0 2.28599999999998e-06 0 2.28609999999998e-06 1 2.28999999999998e-06 1 2.29004999999998e-06 0 2.29199999999998e-06 0 2.29209999999998e-06 1 2.29599999999998e-06 1 2.29604999999998e-06 0 2.29799999999998e-06 0 2.29809999999998e-06 1 2.30199999999998e-06 1 2.30204999999998e-06 0 2.30399999999998e-06 0 2.30409999999998e-06 1 2.30799999999998e-06 1 2.30804999999998e-06 0 2.30999999999998e-06 0 2.31009999999998e-06 1 2.31399999999998e-06 1 2.31404999999998e-06 0 2.31599999999998e-06 0 2.31609999999998e-06 1 2.31999999999998e-06 1 2.32004999999998e-06 0 2.32199999999998e-06 0 2.32209999999998e-06 1 2.32599999999998e-06 1 2.32604999999998e-06 0 2.32799999999998e-06 0 2.32809999999998e-06 1 2.33199999999998e-06 1 2.33204999999998e-06 0 2.33399999999998e-06 0 2.33409999999998e-06 1 2.33799999999998e-06 1 2.33804999999998e-06 0 2.33999999999998e-06 0 2.34009999999998e-06 1 2.34399999999998e-06 1 2.34404999999998e-06 0 2.34599999999998e-06 0 2.34609999999998e-06 1 2.34999999999998e-06 1 2.35004999999998e-06 0 2.35199999999998e-06 0 2.35209999999998e-06 1 2.35599999999998e-06 1 2.35604999999998e-06 0 2.35799999999998e-06 0 2.35809999999998e-06 1 2.36199999999998e-06 1 2.36204999999998e-06 0 2.36399999999998e-06 0 2.36409999999998e-06 1 2.36799999999998e-06 1 2.36804999999998e-06 0 2.36999999999998e-06 0 2.37009999999997e-06 1 2.37399999999998e-06 1 2.37404999999998e-06 0 2.37599999999997e-06 0 2.37609999999997e-06 1 2.37999999999997e-06 1 2.38004999999997e-06 0 2.38199999999997e-06 0 2.38209999999997e-06 1 2.38599999999997e-06 1 2.38604999999997e-06 0 2.38799999999997e-06 0 2.38809999999997e-06 1 2.39199999999997e-06 1 2.39204999999997e-06 0 2.39399999999997e-06 0 2.39409999999997e-06 1 2.39799999999997e-06 1 2.39804999999997e-06 0 2.39999999999997e-06 0 2.40009999999997e-06 1 2.40399999999997e-06 1 2.40404999999997e-06 0 2.40599999999997e-06 0 2.40609999999997e-06 1 2.40999999999997e-06 1 2.41004999999997e-06 0 2.41199999999997e-06 0 2.41209999999997e-06 1 2.41599999999997e-06 1 2.41604999999997e-06 0 2.41799999999997e-06 0 2.41809999999997e-06 1 2.42199999999997e-06 1 2.42204999999997e-06 0 2.42399999999997e-06 0 2.42409999999997e-06 1 2.42799999999997e-06 1 2.42804999999997e-06 0 2.42999999999997e-06 0 2.43009999999997e-06 1 2.43399999999997e-06 1 2.43404999999997e-06 0 2.43599999999997e-06 0 2.43609999999997e-06 1 2.43999999999997e-06 1 2.44004999999997e-06 0 2.44199999999997e-06 0 2.44209999999997e-06 1 2.44599999999997e-06 1 2.44604999999997e-06 0 2.44799999999997e-06 0 2.44809999999997e-06 1 2.45199999999997e-06 1 2.45204999999997e-06 0 2.45399999999997e-06 0 2.45409999999997e-06 1 2.45799999999997e-06 1 2.45804999999997e-06 0 2.45999999999997e-06 0 2.46009999999997e-06 1 2.46399999999997e-06 1 2.46404999999997e-06 0 2.46599999999997e-06 0 2.46609999999997e-06 1 2.46999999999997e-06 1 2.47004999999997e-06 0 2.47199999999997e-06 0 2.47209999999997e-06 1 2.47599999999997e-06 1 2.47604999999997e-06 0 2.47799999999997e-06 0 2.47809999999997e-06 1 2.48199999999997e-06 1 2.48204999999997e-06 0 2.48399999999997e-06 0 2.48409999999997e-06 1 2.48799999999997e-06 1 2.48804999999997e-06 0 2.48999999999997e-06 0 2.49009999999997e-06 1 2.49399999999997e-06 1 2.49404999999997e-06 0 2.49599999999997e-06 0 2.49609999999997e-06 1 2.49999999999997e-06 1 2.50004999999997e-06 0 2.50199999999997e-06 0 2.50209999999997e-06 1 2.50599999999997e-06 1 2.50604999999997e-06 0 2.50799999999997e-06 0 2.50809999999997e-06 1 2.51199999999997e-06 1 2.51204999999997e-06 0 2.51399999999997e-06 0 2.51409999999997e-06 1 2.51799999999997e-06 1 2.51804999999997e-06 0 2.51999999999997e-06 0 2.52009999999997e-06 1 2.52399999999997e-06 1 2.52404999999997e-06 0 2.52599999999996e-06 0 2.52609999999996e-06 1 2.52999999999996e-06 1 2.53004999999996e-06 0 2.53199999999996e-06 0 2.53209999999996e-06 1 2.53599999999996e-06 1 2.53604999999996e-06 0 2.53799999999996e-06 0 2.53809999999996e-06 1 2.54199999999996e-06 1 2.54204999999996e-06 0 2.54399999999996e-06 0 2.54409999999996e-06 1 2.54799999999996e-06 1 2.54804999999996e-06 0 2.54999999999996e-06 0 2.55009999999996e-06 1 2.55399999999996e-06 1 2.55404999999996e-06 0 2.55599999999996e-06 0 2.55609999999996e-06 1 2.55999999999996e-06 1 2.56004999999996e-06 0 2.56199999999996e-06 0 2.56209999999996e-06 1 2.56599999999996e-06 1 2.56604999999996e-06 0 2.56799999999996e-06 0 2.56809999999996e-06 1 2.57199999999996e-06 1 2.57204999999996e-06 0 2.57399999999996e-06 0 2.57409999999996e-06 1 2.57799999999996e-06 1 2.57804999999996e-06 0 2.57999999999996e-06 0 2.58009999999996e-06 1 2.58399999999996e-06 1 2.58404999999996e-06 0 2.58599999999996e-06 0 2.58609999999996e-06 1 2.58999999999996e-06 1 2.59004999999996e-06 0 2.59199999999996e-06 0 2.59209999999996e-06 1 2.59599999999996e-06 1 2.59604999999996e-06 0 2.59799999999996e-06 0 2.59809999999996e-06 1 2.60199999999996e-06 1 2.60204999999996e-06 0 2.60399999999996e-06 0 2.60409999999996e-06 1 2.60799999999996e-06 1 2.60804999999996e-06 0 2.60999999999996e-06 0 2.61009999999996e-06 1 2.61399999999996e-06 1 2.61404999999996e-06 0 2.61599999999996e-06 0 2.61609999999996e-06 1 2.61999999999996e-06 1 2.62004999999996e-06 0 2.62199999999996e-06 0 2.62209999999996e-06 1 2.62599999999996e-06 1 2.62604999999996e-06 0 2.62799999999996e-06 0 2.62809999999996e-06 1 2.63199999999996e-06 1 2.63204999999996e-06 0 2.63399999999996e-06 0 2.63409999999996e-06 1 2.63799999999996e-06 1 2.63804999999996e-06 0 2.63999999999996e-06 0 2.64009999999996e-06 1 2.64399999999996e-06 1 2.64404999999996e-06 0 2.64599999999996e-06 0 2.64609999999996e-06 1 2.64999999999996e-06 1 2.65004999999996e-06 0 2.65199999999996e-06 0 2.65209999999996e-06 1 2.65599999999996e-06 1 2.65604999999996e-06 0 2.65799999999996e-06 0 2.65809999999996e-06 1 2.66199999999996e-06 1 2.66204999999996e-06 0 2.66399999999996e-06 0 2.66409999999996e-06 1 2.66799999999996e-06 1 2.66804999999996e-06 0 2.66999999999996e-06 0 2.67009999999996e-06 1 2.67399999999996e-06 1 2.67404999999996e-06 0 2.67599999999995e-06 0 2.67609999999995e-06 1 2.67999999999995e-06 1 2.68004999999995e-06 0 2.68199999999995e-06 0 2.68209999999995e-06 1 2.68599999999995e-06 1 2.68604999999995e-06 0 2.68799999999995e-06 0 2.68809999999995e-06 1 2.69199999999995e-06 1 2.69204999999995e-06 0 2.69399999999995e-06 0 2.69409999999995e-06 1 2.69799999999995e-06 1 2.69804999999995e-06 0 2.69999999999995e-06 0 2.70009999999995e-06 1 2.70399999999995e-06 1 2.70404999999995e-06 0 2.70599999999995e-06 0 2.70609999999995e-06 1 2.70999999999995e-06 1 2.71004999999995e-06 0 2.71199999999995e-06 0 2.71209999999995e-06 1 2.71599999999995e-06 1 2.71604999999995e-06 0 2.71799999999995e-06 0 2.71809999999995e-06 1 2.72199999999995e-06 1 2.72204999999995e-06 0 2.72399999999995e-06 0 2.72409999999995e-06 1 2.72799999999995e-06 1 2.72804999999995e-06 0 2.72999999999995e-06 0 2.73009999999995e-06 1 2.73399999999995e-06 1 2.73404999999995e-06 0 2.73599999999995e-06 0 2.73609999999995e-06 1 2.73999999999995e-06 1 2.74004999999995e-06 0 2.74199999999995e-06 0 2.74209999999995e-06 1 2.74599999999995e-06 1 2.74604999999995e-06 0 2.74799999999995e-06 0 2.74809999999995e-06 1 2.75199999999995e-06 1 2.75204999999995e-06 0 2.75399999999995e-06 0 2.75409999999995e-06 1 2.75799999999995e-06 1 2.75804999999995e-06 0 2.75999999999995e-06 0 2.76009999999995e-06 1 2.76399999999995e-06 1 2.76404999999995e-06 0 2.76599999999995e-06 0 2.76609999999995e-06 1 2.76999999999995e-06 1 2.77004999999995e-06 0 2.77199999999995e-06 0 2.77209999999995e-06 1 2.77599999999995e-06 1 2.77604999999995e-06 0 2.77799999999995e-06 0 2.77809999999995e-06 1 2.78199999999995e-06 1 2.78204999999995e-06 0 2.78399999999995e-06 0 2.78409999999995e-06 1 2.78799999999995e-06 1 2.78804999999995e-06 0 2.78999999999995e-06 0 2.79009999999995e-06 1 2.79399999999995e-06 1 2.79404999999995e-06 0 2.79599999999995e-06 0 2.79609999999995e-06 1 2.79999999999995e-06 1 2.80004999999995e-06 0 2.80199999999995e-06 0 2.80209999999995e-06 1 2.80599999999995e-06 1 2.80604999999995e-06 0 2.80799999999995e-06 0 2.80809999999995e-06 1 2.81199999999995e-06 1 2.81204999999995e-06 0 2.81399999999995e-06 0 2.81409999999995e-06 1 2.81799999999995e-06 1 2.81804999999995e-06 0 2.81999999999995e-06 0 2.82009999999995e-06 1 2.82399999999995e-06 1 2.82404999999995e-06 0 2.82599999999995e-06 0 2.82609999999994e-06 1 2.82999999999994e-06 1 2.83004999999995e-06 0 2.83199999999994e-06 0 2.83209999999994e-06 1 2.83599999999994e-06 1 2.83604999999994e-06 0 2.83799999999994e-06 0 2.83809999999994e-06 1 2.84199999999994e-06 1 2.84204999999994e-06 0 2.84399999999994e-06 0 2.84409999999994e-06 1 2.84799999999994e-06 1 2.84804999999994e-06 0 2.84999999999994e-06 0 2.85009999999994e-06 1 2.85399999999994e-06 1 2.85404999999994e-06 0 2.85599999999994e-06 0 2.85609999999994e-06 1 2.85999999999994e-06 1 2.86004999999994e-06 0 2.86199999999994e-06 0 2.86209999999994e-06 1 2.86599999999994e-06 1 2.86604999999994e-06 0 2.86799999999994e-06 0 2.86809999999994e-06 1 2.87199999999994e-06 1 2.87204999999994e-06 0 2.87399999999994e-06 0 2.87409999999994e-06 1 2.87799999999994e-06 1 2.87804999999994e-06 0 2.87999999999994e-06 0 2.88009999999994e-06 1 2.88399999999994e-06 1 2.88404999999994e-06 0 2.88599999999994e-06 0 2.88609999999994e-06 1 2.88999999999994e-06 1 2.89004999999994e-06 0 2.89199999999994e-06 0 2.89209999999994e-06 1 2.89599999999994e-06 1 2.89604999999994e-06 0 2.89799999999994e-06 0 2.89809999999994e-06 1 2.90199999999994e-06 1 2.90204999999994e-06 0 2.90399999999994e-06 0 2.90409999999994e-06 1 2.90799999999994e-06 1 2.90804999999994e-06 0 2.90999999999994e-06 0 2.91009999999994e-06 1 2.91399999999994e-06 1 2.91404999999994e-06 0 2.91599999999994e-06 0 2.91609999999994e-06 1 2.91999999999994e-06 1 2.92004999999994e-06 0 2.92199999999994e-06 0 2.92209999999994e-06 1 2.92599999999994e-06 1 2.92604999999994e-06 0 2.92799999999994e-06 0 2.92809999999994e-06 1 2.93199999999994e-06 1 2.93204999999994e-06 0 2.93399999999994e-06 0 2.93409999999994e-06 1 2.93799999999994e-06 1 2.93804999999994e-06 0 2.93999999999994e-06 0 2.94009999999994e-06 1 2.94399999999994e-06 1 2.94404999999994e-06 0 2.94599999999994e-06 0 2.94609999999994e-06 1 2.94999999999994e-06 1 2.95004999999994e-06 0 2.95199999999994e-06 0 2.95209999999994e-06 1 2.95599999999994e-06 1 2.95604999999994e-06 0 2.95799999999994e-06 0 2.95809999999994e-06 1 2.96199999999994e-06 1 2.96204999999994e-06 0 2.96399999999994e-06 0 2.96409999999994e-06 1 2.96799999999994e-06 1 2.96804999999994e-06 0 2.96999999999994e-06 0 2.97009999999994e-06 1 2.97399999999994e-06 1 2.97404999999994e-06 0 2.97599999999994e-06 0 2.97609999999993e-06 1 2.97999999999994e-06 1 2.98004999999994e-06 0 2.98199999999993e-06 0 2.98209999999993e-06 1 2.98599999999993e-06 1 2.98604999999993e-06 0 2.98799999999993e-06 0 2.98809999999993e-06 1 2.99199999999993e-06 1 2.99204999999993e-06 0 2.99399999999993e-06 0 2.99409999999993e-06 1 2.99799999999993e-06 1 2.99804999999993e-06 0 2.99999999999993e-06 0 3.00009999999993e-06 1 3.00399999999993e-06 1 3.00404999999993e-06 0 3.00599999999993e-06 0 3.00609999999993e-06 1 3.00999999999993e-06 1 3.01004999999993e-06 0 3.01199999999993e-06 0 3.01209999999993e-06 1 3.01599999999993e-06 1 3.01604999999993e-06 0 3.01799999999993e-06 0 3.01809999999993e-06 1 3.02199999999993e-06 1 3.02204999999993e-06 0 3.02399999999993e-06 0 3.02409999999993e-06 1 3.02799999999993e-06 1 3.02804999999993e-06 0 3.02999999999993e-06 0 3.03009999999993e-06 1 3.03399999999993e-06 1 3.03404999999993e-06 0 3.03599999999993e-06 0 3.03609999999993e-06 1 3.03999999999993e-06 1 3.04004999999993e-06 0 3.04199999999993e-06 0 3.04209999999993e-06 1 3.04599999999993e-06 1 3.04604999999993e-06 0 3.04799999999993e-06 0 3.04809999999993e-06 1 3.05199999999993e-06 1 3.05204999999993e-06 0 3.05399999999993e-06 0 3.05409999999993e-06 1 3.05799999999993e-06 1 3.05804999999993e-06 0 3.05999999999993e-06 0 3.06009999999993e-06 1 3.06399999999993e-06 1 3.06404999999993e-06 0 3.06599999999993e-06 0 3.06609999999993e-06 1 3.06999999999993e-06 1 3.07004999999993e-06 0 3.07149999999993e-06 0 3.07159999999993e-06 1 3.07699999999993e-06 1]
