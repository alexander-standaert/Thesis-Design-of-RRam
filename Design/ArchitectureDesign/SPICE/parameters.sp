simulator lang=spectre

parameters PWmin = 100n                         //MinimalTransistorWidth
parameters PLmin = 45n                          //MinimalTransistorLenght
parameters WChargeBL = 1e-07         //BitLineChargerWidth(perBL)
parameters WBias = 1.5e-07
parameters WDischargeBL = 1.8e-07   //BitLineDischargerWidth(perBL)
parameters WDischargeSL = 2.25e-07   //SourceLineDischargerWidth(perBL)
parameters Cpar = 0.18e-15                      //ParasiticCapacitor(perCell)
parameters PWn = 1e-07                     //DifferentialNpairWidth(perSA)
parameters PWp = 1e-07                     //DifferentialPpairWidth(perSA)
parameters PWpenable = 1e-07         //SenseAmpEnablePWidth(perSA)
parameters PWnenable = 1e-07         //SenseAmpEnableNWidth(perSA)
parameters PWmuxLB = 2e-07                //PassgateWidth(perMuxLB)
parameters PWmuxGB = 2e-07                //PassgateWidth(perMuxGB)

parameters numberofruns = 1
parameters enableMismatch = 0   //Mismatch
parameters simlength = 6e-08

parameters RMEMHigh = 32500;
parameters RMEMLow = 7500;

parameters Rcell_0_0_0_0 = RMEMLow
parameters Rcell_0_0_0_1 = RMEMHigh
parameters Rcell_0_0_0_2 = RMEMHigh
parameters Rcell_0_0_0_3 = RMEMLow
parameters Rcell_0_0_0_4 = RMEMHigh
parameters Rcell_0_0_0_5 = RMEMLow
parameters Rcell_0_0_0_6 = RMEMLow
parameters Rcell_0_0_0_7 = RMEMLow
parameters Rcell_0_0_0_8 = RMEMLow
parameters Rcell_0_0_0_9 = RMEMLow
parameters Rcell_0_0_0_10 = RMEMLow
parameters Rcell_0_0_0_11 = RMEMLow
parameters Rcell_0_0_0_12 = RMEMLow
parameters Rcell_0_0_0_13 = RMEMHigh
parameters Rcell_0_0_0_14 = RMEMHigh
parameters Rcell_0_0_0_15 = RMEMLow
parameters Rcell_0_0_0_16 = RMEMLow
parameters Rcell_0_0_0_17 = RMEMHigh
parameters Rcell_0_0_0_18 = RMEMLow
parameters Rcell_0_0_0_19 = RMEMLow
parameters Rcell_0_0_0_20 = RMEMHigh
parameters Rcell_0_0_0_21 = RMEMLow
parameters Rcell_0_0_0_22 = RMEMHigh
parameters Rcell_0_0_0_23 = RMEMLow
parameters Rcell_0_0_0_24 = RMEMLow
parameters Rcell_0_0_0_25 = RMEMHigh
parameters Rcell_0_0_0_26 = RMEMHigh
parameters Rcell_0_0_0_27 = RMEMLow
parameters Rcell_0_0_0_28 = RMEMHigh
parameters Rcell_0_0_0_29 = RMEMHigh
parameters Rcell_0_0_0_30 = RMEMLow
parameters Rcell_0_0_0_31 = RMEMHigh
parameters Rcell_0_0_0_32 = RMEMHigh
parameters Rcell_0_0_0_33 = RMEMHigh
parameters Rcell_0_0_0_34 = RMEMLow
parameters Rcell_0_0_0_35 = RMEMLow
parameters Rcell_0_0_0_36 = RMEMLow
parameters Rcell_0_0_0_37 = RMEMLow
parameters Rcell_0_0_0_38 = RMEMHigh
parameters Rcell_0_0_0_39 = RMEMLow
parameters Rcell_0_0_0_40 = RMEMLow
parameters Rcell_0_0_0_41 = RMEMLow
parameters Rcell_0_0_0_42 = RMEMHigh
parameters Rcell_0_0_0_43 = RMEMLow
parameters Rcell_0_0_0_44 = RMEMHigh
parameters Rcell_0_0_0_45 = RMEMLow
parameters Rcell_0_0_0_46 = RMEMLow
parameters Rcell_0_0_0_47 = RMEMLow
parameters Rcell_0_0_0_48 = RMEMHigh
parameters Rcell_0_0_0_49 = RMEMLow
parameters Rcell_0_0_0_50 = RMEMLow
parameters Rcell_0_0_0_51 = RMEMHigh
parameters Rcell_0_0_0_52 = RMEMHigh
parameters Rcell_0_0_0_53 = RMEMLow
parameters Rcell_0_0_0_54 = RMEMHigh
parameters Rcell_0_0_0_55 = RMEMHigh
parameters Rcell_0_0_0_56 = RMEMLow
parameters Rcell_0_0_0_57 = RMEMLow
parameters Rcell_0_0_0_58 = RMEMHigh
parameters Rcell_0_0_0_59 = RMEMHigh
parameters Rcell_0_0_0_60 = RMEMLow
parameters Rcell_0_0_0_61 = RMEMLow
parameters Rcell_0_0_0_62 = RMEMHigh
parameters Rcell_0_0_0_63 = RMEMHigh
parameters Rcell_0_0_1_0 = RMEMHigh
parameters Rcell_0_0_1_1 = RMEMLow
parameters Rcell_0_0_1_2 = RMEMHigh
parameters Rcell_0_0_1_3 = RMEMHigh
parameters Rcell_0_0_1_4 = RMEMHigh
parameters Rcell_0_0_1_5 = RMEMLow
parameters Rcell_0_0_1_6 = RMEMLow
parameters Rcell_0_0_1_7 = RMEMLow
parameters Rcell_0_0_1_8 = RMEMHigh
parameters Rcell_0_0_1_9 = RMEMHigh
parameters Rcell_0_0_1_10 = RMEMLow
parameters Rcell_0_0_1_11 = RMEMHigh
parameters Rcell_0_0_1_12 = RMEMHigh
parameters Rcell_0_0_1_13 = RMEMHigh
parameters Rcell_0_0_1_14 = RMEMLow
parameters Rcell_0_0_1_15 = RMEMLow
parameters Rcell_0_0_1_16 = RMEMHigh
parameters Rcell_0_0_1_17 = RMEMHigh
parameters Rcell_0_0_1_18 = RMEMLow
parameters Rcell_0_0_1_19 = RMEMLow
parameters Rcell_0_0_1_20 = RMEMHigh
parameters Rcell_0_0_1_21 = RMEMLow
parameters Rcell_0_0_1_22 = RMEMHigh
parameters Rcell_0_0_1_23 = RMEMHigh
parameters Rcell_0_0_1_24 = RMEMLow
parameters Rcell_0_0_1_25 = RMEMLow
parameters Rcell_0_0_1_26 = RMEMLow
parameters Rcell_0_0_1_27 = RMEMHigh
parameters Rcell_0_0_1_28 = RMEMHigh
parameters Rcell_0_0_1_29 = RMEMHigh
parameters Rcell_0_0_1_30 = RMEMLow
parameters Rcell_0_0_1_31 = RMEMHigh
parameters Rcell_0_0_1_32 = RMEMHigh
parameters Rcell_0_0_1_33 = RMEMLow
parameters Rcell_0_0_1_34 = RMEMLow
parameters Rcell_0_0_1_35 = RMEMHigh
parameters Rcell_0_0_1_36 = RMEMHigh
parameters Rcell_0_0_1_37 = RMEMHigh
parameters Rcell_0_0_1_38 = RMEMLow
parameters Rcell_0_0_1_39 = RMEMLow
parameters Rcell_0_0_1_40 = RMEMLow
parameters Rcell_0_0_1_41 = RMEMHigh
parameters Rcell_0_0_1_42 = RMEMLow
parameters Rcell_0_0_1_43 = RMEMLow
parameters Rcell_0_0_1_44 = RMEMLow
parameters Rcell_0_0_1_45 = RMEMHigh
parameters Rcell_0_0_1_46 = RMEMLow
parameters Rcell_0_0_1_47 = RMEMHigh
parameters Rcell_0_0_1_48 = RMEMHigh
parameters Rcell_0_0_1_49 = RMEMHigh
parameters Rcell_0_0_1_50 = RMEMHigh
parameters Rcell_0_0_1_51 = RMEMLow
parameters Rcell_0_0_1_52 = RMEMHigh
parameters Rcell_0_0_1_53 = RMEMHigh
parameters Rcell_0_0_1_54 = RMEMHigh
parameters Rcell_0_0_1_55 = RMEMHigh
parameters Rcell_0_0_1_56 = RMEMHigh
parameters Rcell_0_0_1_57 = RMEMHigh
parameters Rcell_0_0_1_58 = RMEMLow
parameters Rcell_0_0_1_59 = RMEMLow
parameters Rcell_0_0_1_60 = RMEMLow
parameters Rcell_0_0_1_61 = RMEMLow
parameters Rcell_0_0_1_62 = RMEMLow
parameters Rcell_0_0_1_63 = RMEMHigh
parameters Rcell_0_0_2_0 = RMEMLow
parameters Rcell_0_0_2_1 = RMEMLow
parameters Rcell_0_0_2_2 = RMEMLow
parameters Rcell_0_0_2_3 = RMEMHigh
parameters Rcell_0_0_2_4 = RMEMHigh
parameters Rcell_0_0_2_5 = RMEMLow
parameters Rcell_0_0_2_6 = RMEMLow
parameters Rcell_0_0_2_7 = RMEMHigh
parameters Rcell_0_0_2_8 = RMEMHigh
parameters Rcell_0_0_2_9 = RMEMHigh
parameters Rcell_0_0_2_10 = RMEMHigh
parameters Rcell_0_0_2_11 = RMEMHigh
parameters Rcell_0_0_2_12 = RMEMHigh
parameters Rcell_0_0_2_13 = RMEMLow
parameters Rcell_0_0_2_14 = RMEMHigh
parameters Rcell_0_0_2_15 = RMEMLow
parameters Rcell_0_0_2_16 = RMEMHigh
parameters Rcell_0_0_2_17 = RMEMHigh
parameters Rcell_0_0_2_18 = RMEMHigh
parameters Rcell_0_0_2_19 = RMEMLow
parameters Rcell_0_0_2_20 = RMEMLow
parameters Rcell_0_0_2_21 = RMEMLow
parameters Rcell_0_0_2_22 = RMEMLow
parameters Rcell_0_0_2_23 = RMEMLow
parameters Rcell_0_0_2_24 = RMEMLow
parameters Rcell_0_0_2_25 = RMEMLow
parameters Rcell_0_0_2_26 = RMEMHigh
parameters Rcell_0_0_2_27 = RMEMHigh
parameters Rcell_0_0_2_28 = RMEMHigh
parameters Rcell_0_0_2_29 = RMEMHigh
parameters Rcell_0_0_2_30 = RMEMLow
parameters Rcell_0_0_2_31 = RMEMHigh
parameters Rcell_0_0_2_32 = RMEMLow
parameters Rcell_0_0_2_33 = RMEMLow
parameters Rcell_0_0_2_34 = RMEMHigh
parameters Rcell_0_0_2_35 = RMEMHigh
parameters Rcell_0_0_2_36 = RMEMLow
parameters Rcell_0_0_2_37 = RMEMHigh
parameters Rcell_0_0_2_38 = RMEMHigh
parameters Rcell_0_0_2_39 = RMEMLow
parameters Rcell_0_0_2_40 = RMEMLow
parameters Rcell_0_0_2_41 = RMEMLow
parameters Rcell_0_0_2_42 = RMEMHigh
parameters Rcell_0_0_2_43 = RMEMHigh
parameters Rcell_0_0_2_44 = RMEMLow
parameters Rcell_0_0_2_45 = RMEMHigh
parameters Rcell_0_0_2_46 = RMEMHigh
parameters Rcell_0_0_2_47 = RMEMLow
parameters Rcell_0_0_2_48 = RMEMLow
parameters Rcell_0_0_2_49 = RMEMHigh
parameters Rcell_0_0_2_50 = RMEMHigh
parameters Rcell_0_0_2_51 = RMEMLow
parameters Rcell_0_0_2_52 = RMEMLow
parameters Rcell_0_0_2_53 = RMEMLow
parameters Rcell_0_0_2_54 = RMEMLow
parameters Rcell_0_0_2_55 = RMEMLow
parameters Rcell_0_0_2_56 = RMEMHigh
parameters Rcell_0_0_2_57 = RMEMLow
parameters Rcell_0_0_2_58 = RMEMLow
parameters Rcell_0_0_2_59 = RMEMLow
parameters Rcell_0_0_2_60 = RMEMHigh
parameters Rcell_0_0_2_61 = RMEMLow
parameters Rcell_0_0_2_62 = RMEMHigh
parameters Rcell_0_0_2_63 = RMEMLow
parameters Rcell_0_0_3_0 = RMEMLow
parameters Rcell_0_0_3_1 = RMEMLow
parameters Rcell_0_0_3_2 = RMEMHigh
parameters Rcell_0_0_3_3 = RMEMLow
parameters Rcell_0_0_3_4 = RMEMHigh
parameters Rcell_0_0_3_5 = RMEMLow
parameters Rcell_0_0_3_6 = RMEMLow
parameters Rcell_0_0_3_7 = RMEMHigh
parameters Rcell_0_0_3_8 = RMEMLow
parameters Rcell_0_0_3_9 = RMEMHigh
parameters Rcell_0_0_3_10 = RMEMHigh
parameters Rcell_0_0_3_11 = RMEMHigh
parameters Rcell_0_0_3_12 = RMEMHigh
parameters Rcell_0_0_3_13 = RMEMHigh
parameters Rcell_0_0_3_14 = RMEMLow
parameters Rcell_0_0_3_15 = RMEMLow
parameters Rcell_0_0_3_16 = RMEMHigh
parameters Rcell_0_0_3_17 = RMEMLow
parameters Rcell_0_0_3_18 = RMEMHigh
parameters Rcell_0_0_3_19 = RMEMHigh
parameters Rcell_0_0_3_20 = RMEMHigh
parameters Rcell_0_0_3_21 = RMEMHigh
parameters Rcell_0_0_3_22 = RMEMLow
parameters Rcell_0_0_3_23 = RMEMLow
parameters Rcell_0_0_3_24 = RMEMHigh
parameters Rcell_0_0_3_25 = RMEMHigh
parameters Rcell_0_0_3_26 = RMEMHigh
parameters Rcell_0_0_3_27 = RMEMHigh
parameters Rcell_0_0_3_28 = RMEMHigh
parameters Rcell_0_0_3_29 = RMEMHigh
parameters Rcell_0_0_3_30 = RMEMHigh
parameters Rcell_0_0_3_31 = RMEMLow
parameters Rcell_0_0_3_32 = RMEMHigh
parameters Rcell_0_0_3_33 = RMEMLow
parameters Rcell_0_0_3_34 = RMEMHigh
parameters Rcell_0_0_3_35 = RMEMLow
parameters Rcell_0_0_3_36 = RMEMHigh
parameters Rcell_0_0_3_37 = RMEMLow
parameters Rcell_0_0_3_38 = RMEMLow
parameters Rcell_0_0_3_39 = RMEMHigh
parameters Rcell_0_0_3_40 = RMEMHigh
parameters Rcell_0_0_3_41 = RMEMHigh
parameters Rcell_0_0_3_42 = RMEMHigh
parameters Rcell_0_0_3_43 = RMEMHigh
parameters Rcell_0_0_3_44 = RMEMHigh
parameters Rcell_0_0_3_45 = RMEMHigh
parameters Rcell_0_0_3_46 = RMEMHigh
parameters Rcell_0_0_3_47 = RMEMHigh
parameters Rcell_0_0_3_48 = RMEMHigh
parameters Rcell_0_0_3_49 = RMEMLow
parameters Rcell_0_0_3_50 = RMEMHigh
parameters Rcell_0_0_3_51 = RMEMLow
parameters Rcell_0_0_3_52 = RMEMHigh
parameters Rcell_0_0_3_53 = RMEMLow
parameters Rcell_0_0_3_54 = RMEMLow
parameters Rcell_0_0_3_55 = RMEMHigh
parameters Rcell_0_0_3_56 = RMEMHigh
parameters Rcell_0_0_3_57 = RMEMHigh
parameters Rcell_0_0_3_58 = RMEMLow
parameters Rcell_0_0_3_59 = RMEMHigh
parameters Rcell_0_0_3_60 = RMEMHigh
parameters Rcell_0_0_3_61 = RMEMLow
parameters Rcell_0_0_3_62 = RMEMHigh
parameters Rcell_0_0_3_63 = RMEMHigh
parameters Rcell_0_1_0_0 = RMEMLow
parameters Rcell_0_1_0_1 = RMEMHigh
parameters Rcell_0_1_0_2 = RMEMLow
parameters Rcell_0_1_0_3 = RMEMLow
parameters Rcell_0_1_0_4 = RMEMLow
parameters Rcell_0_1_0_5 = RMEMHigh
parameters Rcell_0_1_0_6 = RMEMHigh
parameters Rcell_0_1_0_7 = RMEMHigh
parameters Rcell_0_1_0_8 = RMEMHigh
parameters Rcell_0_1_0_9 = RMEMHigh
parameters Rcell_0_1_0_10 = RMEMHigh
parameters Rcell_0_1_0_11 = RMEMHigh
parameters Rcell_0_1_0_12 = RMEMLow
parameters Rcell_0_1_0_13 = RMEMHigh
parameters Rcell_0_1_0_14 = RMEMLow
parameters Rcell_0_1_0_15 = RMEMLow
parameters Rcell_0_1_0_16 = RMEMLow
parameters Rcell_0_1_0_17 = RMEMLow
parameters Rcell_0_1_0_18 = RMEMHigh
parameters Rcell_0_1_0_19 = RMEMHigh
parameters Rcell_0_1_0_20 = RMEMLow
parameters Rcell_0_1_0_21 = RMEMLow
parameters Rcell_0_1_0_22 = RMEMHigh
parameters Rcell_0_1_0_23 = RMEMLow
parameters Rcell_0_1_0_24 = RMEMLow
parameters Rcell_0_1_0_25 = RMEMHigh
parameters Rcell_0_1_0_26 = RMEMHigh
parameters Rcell_0_1_0_27 = RMEMLow
parameters Rcell_0_1_0_28 = RMEMLow
parameters Rcell_0_1_0_29 = RMEMLow
parameters Rcell_0_1_0_30 = RMEMHigh
parameters Rcell_0_1_0_31 = RMEMHigh
parameters Rcell_0_1_0_32 = RMEMHigh
parameters Rcell_0_1_0_33 = RMEMLow
parameters Rcell_0_1_0_34 = RMEMHigh
parameters Rcell_0_1_0_35 = RMEMLow
parameters Rcell_0_1_0_36 = RMEMHigh
parameters Rcell_0_1_0_37 = RMEMHigh
parameters Rcell_0_1_0_38 = RMEMLow
parameters Rcell_0_1_0_39 = RMEMLow
parameters Rcell_0_1_0_40 = RMEMLow
parameters Rcell_0_1_0_41 = RMEMHigh
parameters Rcell_0_1_0_42 = RMEMLow
parameters Rcell_0_1_0_43 = RMEMLow
parameters Rcell_0_1_0_44 = RMEMLow
parameters Rcell_0_1_0_45 = RMEMHigh
parameters Rcell_0_1_0_46 = RMEMHigh
parameters Rcell_0_1_0_47 = RMEMHigh
parameters Rcell_0_1_0_48 = RMEMLow
parameters Rcell_0_1_0_49 = RMEMLow
parameters Rcell_0_1_0_50 = RMEMHigh
parameters Rcell_0_1_0_51 = RMEMLow
parameters Rcell_0_1_0_52 = RMEMHigh
parameters Rcell_0_1_0_53 = RMEMLow
parameters Rcell_0_1_0_54 = RMEMLow
parameters Rcell_0_1_0_55 = RMEMLow
parameters Rcell_0_1_0_56 = RMEMHigh
parameters Rcell_0_1_0_57 = RMEMHigh
parameters Rcell_0_1_0_58 = RMEMHigh
parameters Rcell_0_1_0_59 = RMEMLow
parameters Rcell_0_1_0_60 = RMEMLow
parameters Rcell_0_1_0_61 = RMEMLow
parameters Rcell_0_1_0_62 = RMEMLow
parameters Rcell_0_1_0_63 = RMEMHigh
parameters Rcell_0_1_1_0 = RMEMHigh
parameters Rcell_0_1_1_1 = RMEMHigh
parameters Rcell_0_1_1_2 = RMEMHigh
parameters Rcell_0_1_1_3 = RMEMLow
parameters Rcell_0_1_1_4 = RMEMHigh
parameters Rcell_0_1_1_5 = RMEMLow
parameters Rcell_0_1_1_6 = RMEMHigh
parameters Rcell_0_1_1_7 = RMEMHigh
parameters Rcell_0_1_1_8 = RMEMHigh
parameters Rcell_0_1_1_9 = RMEMLow
parameters Rcell_0_1_1_10 = RMEMLow
parameters Rcell_0_1_1_11 = RMEMHigh
parameters Rcell_0_1_1_12 = RMEMHigh
parameters Rcell_0_1_1_13 = RMEMHigh
parameters Rcell_0_1_1_14 = RMEMHigh
parameters Rcell_0_1_1_15 = RMEMHigh
parameters Rcell_0_1_1_16 = RMEMHigh
parameters Rcell_0_1_1_17 = RMEMHigh
parameters Rcell_0_1_1_18 = RMEMLow
parameters Rcell_0_1_1_19 = RMEMHigh
parameters Rcell_0_1_1_20 = RMEMLow
parameters Rcell_0_1_1_21 = RMEMLow
parameters Rcell_0_1_1_22 = RMEMHigh
parameters Rcell_0_1_1_23 = RMEMLow
parameters Rcell_0_1_1_24 = RMEMHigh
parameters Rcell_0_1_1_25 = RMEMLow
parameters Rcell_0_1_1_26 = RMEMHigh
parameters Rcell_0_1_1_27 = RMEMLow
parameters Rcell_0_1_1_28 = RMEMLow
parameters Rcell_0_1_1_29 = RMEMHigh
parameters Rcell_0_1_1_30 = RMEMLow
parameters Rcell_0_1_1_31 = RMEMLow
parameters Rcell_0_1_1_32 = RMEMLow
parameters Rcell_0_1_1_33 = RMEMLow
parameters Rcell_0_1_1_34 = RMEMLow
parameters Rcell_0_1_1_35 = RMEMHigh
parameters Rcell_0_1_1_36 = RMEMHigh
parameters Rcell_0_1_1_37 = RMEMHigh
parameters Rcell_0_1_1_38 = RMEMHigh
parameters Rcell_0_1_1_39 = RMEMLow
parameters Rcell_0_1_1_40 = RMEMHigh
parameters Rcell_0_1_1_41 = RMEMHigh
parameters Rcell_0_1_1_42 = RMEMHigh
parameters Rcell_0_1_1_43 = RMEMLow
parameters Rcell_0_1_1_44 = RMEMHigh
parameters Rcell_0_1_1_45 = RMEMLow
parameters Rcell_0_1_1_46 = RMEMLow
parameters Rcell_0_1_1_47 = RMEMLow
parameters Rcell_0_1_1_48 = RMEMHigh
parameters Rcell_0_1_1_49 = RMEMHigh
parameters Rcell_0_1_1_50 = RMEMLow
parameters Rcell_0_1_1_51 = RMEMLow
parameters Rcell_0_1_1_52 = RMEMLow
parameters Rcell_0_1_1_53 = RMEMHigh
parameters Rcell_0_1_1_54 = RMEMLow
parameters Rcell_0_1_1_55 = RMEMHigh
parameters Rcell_0_1_1_56 = RMEMHigh
parameters Rcell_0_1_1_57 = RMEMLow
parameters Rcell_0_1_1_58 = RMEMLow
parameters Rcell_0_1_1_59 = RMEMHigh
parameters Rcell_0_1_1_60 = RMEMHigh
parameters Rcell_0_1_1_61 = RMEMLow
parameters Rcell_0_1_1_62 = RMEMLow
parameters Rcell_0_1_1_63 = RMEMLow
parameters Rcell_0_1_2_0 = RMEMHigh
parameters Rcell_0_1_2_1 = RMEMLow
parameters Rcell_0_1_2_2 = RMEMHigh
parameters Rcell_0_1_2_3 = RMEMLow
parameters Rcell_0_1_2_4 = RMEMLow
parameters Rcell_0_1_2_5 = RMEMLow
parameters Rcell_0_1_2_6 = RMEMHigh
parameters Rcell_0_1_2_7 = RMEMHigh
parameters Rcell_0_1_2_8 = RMEMLow
parameters Rcell_0_1_2_9 = RMEMHigh
parameters Rcell_0_1_2_10 = RMEMHigh
parameters Rcell_0_1_2_11 = RMEMHigh
parameters Rcell_0_1_2_12 = RMEMHigh
parameters Rcell_0_1_2_13 = RMEMLow
parameters Rcell_0_1_2_14 = RMEMLow
parameters Rcell_0_1_2_15 = RMEMLow
parameters Rcell_0_1_2_16 = RMEMHigh
parameters Rcell_0_1_2_17 = RMEMLow
parameters Rcell_0_1_2_18 = RMEMHigh
parameters Rcell_0_1_2_19 = RMEMLow
parameters Rcell_0_1_2_20 = RMEMHigh
parameters Rcell_0_1_2_21 = RMEMHigh
parameters Rcell_0_1_2_22 = RMEMLow
parameters Rcell_0_1_2_23 = RMEMHigh
parameters Rcell_0_1_2_24 = RMEMLow
parameters Rcell_0_1_2_25 = RMEMHigh
parameters Rcell_0_1_2_26 = RMEMLow
parameters Rcell_0_1_2_27 = RMEMLow
parameters Rcell_0_1_2_28 = RMEMLow
parameters Rcell_0_1_2_29 = RMEMLow
parameters Rcell_0_1_2_30 = RMEMLow
parameters Rcell_0_1_2_31 = RMEMHigh
parameters Rcell_0_1_2_32 = RMEMHigh
parameters Rcell_0_1_2_33 = RMEMLow
parameters Rcell_0_1_2_34 = RMEMLow
parameters Rcell_0_1_2_35 = RMEMHigh
parameters Rcell_0_1_2_36 = RMEMHigh
parameters Rcell_0_1_2_37 = RMEMLow
parameters Rcell_0_1_2_38 = RMEMHigh
parameters Rcell_0_1_2_39 = RMEMHigh
parameters Rcell_0_1_2_40 = RMEMHigh
parameters Rcell_0_1_2_41 = RMEMHigh
parameters Rcell_0_1_2_42 = RMEMLow
parameters Rcell_0_1_2_43 = RMEMLow
parameters Rcell_0_1_2_44 = RMEMHigh
parameters Rcell_0_1_2_45 = RMEMLow
parameters Rcell_0_1_2_46 = RMEMLow
parameters Rcell_0_1_2_47 = RMEMLow
parameters Rcell_0_1_2_48 = RMEMHigh
parameters Rcell_0_1_2_49 = RMEMHigh
parameters Rcell_0_1_2_50 = RMEMHigh
parameters Rcell_0_1_2_51 = RMEMHigh
parameters Rcell_0_1_2_52 = RMEMHigh
parameters Rcell_0_1_2_53 = RMEMLow
parameters Rcell_0_1_2_54 = RMEMHigh
parameters Rcell_0_1_2_55 = RMEMHigh
parameters Rcell_0_1_2_56 = RMEMLow
parameters Rcell_0_1_2_57 = RMEMLow
parameters Rcell_0_1_2_58 = RMEMLow
parameters Rcell_0_1_2_59 = RMEMLow
parameters Rcell_0_1_2_60 = RMEMLow
parameters Rcell_0_1_2_61 = RMEMLow
parameters Rcell_0_1_2_62 = RMEMLow
parameters Rcell_0_1_2_63 = RMEMLow
parameters Rcell_0_1_3_0 = RMEMLow
parameters Rcell_0_1_3_1 = RMEMHigh
parameters Rcell_0_1_3_2 = RMEMHigh
parameters Rcell_0_1_3_3 = RMEMHigh
parameters Rcell_0_1_3_4 = RMEMHigh
parameters Rcell_0_1_3_5 = RMEMHigh
parameters Rcell_0_1_3_6 = RMEMHigh
parameters Rcell_0_1_3_7 = RMEMHigh
parameters Rcell_0_1_3_8 = RMEMLow
parameters Rcell_0_1_3_9 = RMEMHigh
parameters Rcell_0_1_3_10 = RMEMLow
parameters Rcell_0_1_3_11 = RMEMHigh
parameters Rcell_0_1_3_12 = RMEMLow
parameters Rcell_0_1_3_13 = RMEMLow
parameters Rcell_0_1_3_14 = RMEMLow
parameters Rcell_0_1_3_15 = RMEMLow
parameters Rcell_0_1_3_16 = RMEMHigh
parameters Rcell_0_1_3_17 = RMEMHigh
parameters Rcell_0_1_3_18 = RMEMLow
parameters Rcell_0_1_3_19 = RMEMHigh
parameters Rcell_0_1_3_20 = RMEMHigh
parameters Rcell_0_1_3_21 = RMEMHigh
parameters Rcell_0_1_3_22 = RMEMLow
parameters Rcell_0_1_3_23 = RMEMHigh
parameters Rcell_0_1_3_24 = RMEMHigh
parameters Rcell_0_1_3_25 = RMEMHigh
parameters Rcell_0_1_3_26 = RMEMLow
parameters Rcell_0_1_3_27 = RMEMHigh
parameters Rcell_0_1_3_28 = RMEMLow
parameters Rcell_0_1_3_29 = RMEMHigh
parameters Rcell_0_1_3_30 = RMEMHigh
parameters Rcell_0_1_3_31 = RMEMHigh
parameters Rcell_0_1_3_32 = RMEMLow
parameters Rcell_0_1_3_33 = RMEMHigh
parameters Rcell_0_1_3_34 = RMEMHigh
parameters Rcell_0_1_3_35 = RMEMLow
parameters Rcell_0_1_3_36 = RMEMLow
parameters Rcell_0_1_3_37 = RMEMHigh
parameters Rcell_0_1_3_38 = RMEMLow
parameters Rcell_0_1_3_39 = RMEMLow
parameters Rcell_0_1_3_40 = RMEMHigh
parameters Rcell_0_1_3_41 = RMEMHigh
parameters Rcell_0_1_3_42 = RMEMHigh
parameters Rcell_0_1_3_43 = RMEMLow
parameters Rcell_0_1_3_44 = RMEMLow
parameters Rcell_0_1_3_45 = RMEMLow
parameters Rcell_0_1_3_46 = RMEMHigh
parameters Rcell_0_1_3_47 = RMEMHigh
parameters Rcell_0_1_3_48 = RMEMHigh
parameters Rcell_0_1_3_49 = RMEMLow
parameters Rcell_0_1_3_50 = RMEMLow
parameters Rcell_0_1_3_51 = RMEMHigh
parameters Rcell_0_1_3_52 = RMEMLow
parameters Rcell_0_1_3_53 = RMEMHigh
parameters Rcell_0_1_3_54 = RMEMHigh
parameters Rcell_0_1_3_55 = RMEMHigh
parameters Rcell_0_1_3_56 = RMEMLow
parameters Rcell_0_1_3_57 = RMEMHigh
parameters Rcell_0_1_3_58 = RMEMLow
parameters Rcell_0_1_3_59 = RMEMHigh
parameters Rcell_0_1_3_60 = RMEMLow
parameters Rcell_0_1_3_61 = RMEMLow
parameters Rcell_0_1_3_62 = RMEMHigh
parameters Rcell_0_1_3_63 = RMEMLow

parameters Rref_0 = RMEMHigh
parameters Rref_2 = RMEMHigh
parameters Rref_1 = RMEMLow
parameters Rref_3 = RMEMLow

parameters waveEnGB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53710000000002e-06 1 1.54100000000002e-06 1 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveEnLB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29905000000003e-06 0 2.30300000000003e-06 0 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68305000000004e-06 0 2.68700000000004e-06 0 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87505000000004e-06 0 2.87900000000004e-06 0 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97105000000004e-06 0 2.97500000000004e-06 0 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01905000000004e-06 0 3.02300000000004e-06 0 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04305000000004e-06 0 3.04700000000004e-06 0 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05505000000004e-06 0 3.05900000000004e-06 0 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06105000000004e-06 0 3.06500000000004e-06 0 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06705000000004e-06 0 3.07100000000004e-06 0 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveEnLB_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63049999999997e-07 0 7.66999999999997e-07 0 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.14705e-06 0 1.151e-06 0 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33905000000001e-06 0 1.34300000000001e-06 0 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43505000000001e-06 0 1.43900000000001e-06 0 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48305000000002e-06 0 1.48700000000002e-06 0 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50705000000002e-06 0 1.51100000000002e-06 0 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51905000000002e-06 0 1.52300000000002e-06 0 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52505000000002e-06 0 1.52900000000002e-06 0 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53105000000002e-06 0 1.53500000000002e-06 0 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53710000000002e-06 1 1.54100000000002e-06 1 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveBLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85100000000001e-07 1 3.89000000000001e-07 1 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.14705e-06 0 1.151e-06 0 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92110000000003e-06 1 1.92500000000003e-06 1 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68305000000004e-06 0 2.68700000000004e-06 0 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveBLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79050000000001e-07 0 3.83000000000001e-07 0 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63049999999997e-07 0 7.66999999999997e-07 0 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69099999999997e-07 1 7.72999999999997e-07 1 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.1531e-06 1 1.157e-06 1 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91505000000003e-06 0 1.91900000000003e-06 0 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29905000000003e-06 0 2.30300000000003e-06 0 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30510000000003e-06 1 2.30900000000003e-06 1 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68910000000004e-06 1 2.69300000000004e-06 1 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73050000000001e-07 0 3.77000000000001e-07 0 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91100000000001e-07 1 3.95000000000001e-07 1 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57049999999997e-07 0 7.60999999999997e-07 0 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75099999999997e-07 1 7.78999999999997e-07 1 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.14105e-06 0 1.145e-06 0 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.1591e-06 1 1.163e-06 1 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52505000000002e-06 0 1.52900000000002e-06 0 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54310000000002e-06 1 1.54700000000002e-06 1 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90905000000003e-06 0 1.91300000000003e-06 0 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92710000000003e-06 1 1.93100000000003e-06 1 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29305000000003e-06 0 2.29700000000003e-06 0 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31110000000003e-06 1 2.31500000000003e-06 1 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67705000000004e-06 0 2.68100000000004e-06 0 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69510000000004e-06 1 2.69900000000004e-06 1 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06105000000004e-06 0 3.06500000000004e-06 0 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.6105e-07 0 3.65e-07 0 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67050000000001e-07 0 3.71000000000001e-07 0 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97100000000001e-07 1 4.01000000000001e-07 1 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03100000000001e-07 1 4.07000000000001e-07 1 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45049999999998e-07 0 7.48999999999998e-07 0 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51049999999997e-07 0 7.54999999999997e-07 0 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81099999999997e-07 1 7.84999999999997e-07 1 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87099999999997e-07 1 7.90999999999997e-07 1 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.12905e-06 0 1.133e-06 0 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.13505e-06 0 1.139e-06 0 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.1651e-06 1 1.169e-06 1 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.1711e-06 1 1.175e-06 1 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51305000000002e-06 0 1.51700000000002e-06 0 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51905000000002e-06 0 1.52300000000002e-06 0 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54910000000002e-06 1 1.55300000000002e-06 1 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55510000000002e-06 1 1.55900000000002e-06 1 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89705000000003e-06 0 1.90100000000003e-06 0 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90305000000003e-06 0 1.90700000000003e-06 0 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93310000000003e-06 1 1.93700000000003e-06 1 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93910000000003e-06 1 1.94300000000003e-06 1 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28105000000003e-06 0 2.28500000000003e-06 0 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28705000000003e-06 0 2.29100000000003e-06 0 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31710000000003e-06 1 2.32100000000003e-06 1 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32310000000003e-06 1 2.32700000000003e-06 1 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66505000000004e-06 0 2.66900000000004e-06 0 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67105000000004e-06 0 2.67500000000004e-06 0 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70110000000004e-06 1 2.70500000000004e-06 1 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70710000000004e-06 1 2.71100000000004e-06 1 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04905000000004e-06 0 3.05300000000004e-06 0 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05505000000004e-06 0 3.05900000000004e-06 0 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_2=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.3705e-07 0 3.41e-07 0 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.4305e-07 0 3.47e-07 0 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.4905e-07 0 3.53e-07 0 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.5505e-07 0 3.59e-07 0 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09100000000001e-07 1 4.13000000000001e-07 1 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15100000000001e-07 1 4.19000000000001e-07 1 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21100000000001e-07 1 4.25000000000001e-07 1 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27100000000001e-07 1 4.31000000000001e-07 1 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21049999999998e-07 0 7.24999999999998e-07 0 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27049999999998e-07 0 7.30999999999998e-07 0 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33049999999998e-07 0 7.36999999999998e-07 0 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39049999999998e-07 0 7.42999999999998e-07 0 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93099999999997e-07 1 7.96999999999997e-07 1 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99099999999997e-07 1 8.02999999999997e-07 1 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05099999999997e-07 1 8.08999999999997e-07 1 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11099999999997e-07 1 8.14999999999997e-07 1 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.10505e-06 0 1.109e-06 0 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.11105e-06 0 1.115e-06 0 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.11705e-06 0 1.121e-06 0 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.12305e-06 0 1.127e-06 0 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.1771e-06 1 1.181e-06 1 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.1831e-06 1 1.187e-06 1 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.1891e-06 1 1.193e-06 1 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.1951e-06 1 1.199e-06 1 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48905000000002e-06 0 1.49300000000002e-06 0 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49505000000002e-06 0 1.49900000000002e-06 0 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50105000000002e-06 0 1.50500000000002e-06 0 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50705000000002e-06 0 1.51100000000002e-06 0 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56110000000002e-06 1 1.56500000000002e-06 1 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56710000000002e-06 1 1.57100000000002e-06 1 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57310000000002e-06 1 1.57700000000002e-06 1 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57910000000002e-06 1 1.58300000000002e-06 1 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87305000000003e-06 0 1.87700000000003e-06 0 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87905000000003e-06 0 1.88300000000003e-06 0 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88505000000003e-06 0 1.88900000000003e-06 0 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89105000000003e-06 0 1.89500000000003e-06 0 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94510000000003e-06 1 1.94900000000003e-06 1 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95110000000003e-06 1 1.95500000000003e-06 1 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95710000000003e-06 1 1.96100000000003e-06 1 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96310000000003e-06 1 1.96700000000003e-06 1 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25705000000003e-06 0 2.26100000000003e-06 0 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26305000000003e-06 0 2.26700000000003e-06 0 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26905000000003e-06 0 2.27300000000003e-06 0 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27505000000003e-06 0 2.27900000000003e-06 0 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32910000000003e-06 1 2.33300000000003e-06 1 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33510000000003e-06 1 2.33900000000003e-06 1 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34110000000003e-06 1 2.34500000000003e-06 1 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34710000000003e-06 1 2.35100000000003e-06 1 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64105000000004e-06 0 2.64500000000004e-06 0 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64705000000004e-06 0 2.65100000000004e-06 0 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65305000000004e-06 0 2.65700000000004e-06 0 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65905000000004e-06 0 2.66300000000004e-06 0 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71310000000004e-06 1 2.71700000000004e-06 1 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71910000000004e-06 1 2.72300000000004e-06 1 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72510000000004e-06 1 2.72900000000004e-06 1 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73110000000004e-06 1 2.73500000000004e-06 1 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02505000000004e-06 0 3.02900000000004e-06 0 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03105000000004e-06 0 3.03500000000004e-06 0 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03705000000004e-06 0 3.04100000000004e-06 0 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04305000000004e-06 0 3.04700000000004e-06 0 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_3=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.8905e-07 0 2.93e-07 0 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.9505e-07 0 2.99e-07 0 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.0105e-07 0 3.05e-07 0 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.0705e-07 0 3.11e-07 0 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.1305e-07 0 3.17e-07 0 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.1905e-07 0 3.23e-07 0 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.2505e-07 0 3.29e-07 0 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.3105e-07 0 3.35e-07 0 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33100000000001e-07 1 4.37000000000001e-07 1 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39100000000001e-07 1 4.43000000000001e-07 1 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45100000000001e-07 1 4.49000000000001e-07 1 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51100000000001e-07 1 4.55000000000001e-07 1 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57100000000001e-07 1 4.61000000000001e-07 1 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63100000000001e-07 1 4.67000000000001e-07 1 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69100000000001e-07 1 4.73000000000001e-07 1 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75100000000001e-07 1 4.79000000000001e-07 1 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73049999999998e-07 0 6.76999999999998e-07 0 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79049999999998e-07 0 6.82999999999998e-07 0 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85049999999998e-07 0 6.88999999999998e-07 0 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91049999999998e-07 0 6.94999999999998e-07 0 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97049999999998e-07 0 7.00999999999998e-07 0 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03049999999998e-07 0 7.06999999999998e-07 0 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09049999999998e-07 0 7.12999999999998e-07 0 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15049999999998e-07 0 7.18999999999998e-07 0 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17099999999997e-07 1 8.20999999999997e-07 1 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23099999999997e-07 1 8.26999999999996e-07 1 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29099999999996e-07 1 8.32999999999996e-07 1 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35099999999996e-07 1 8.38999999999996e-07 1 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41099999999996e-07 1 8.44999999999996e-07 1 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47099999999996e-07 1 8.50999999999996e-07 1 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53099999999996e-07 1 8.56999999999996e-07 1 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59099999999996e-07 1 8.62999999999996e-07 1 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.05705e-06 0 1.061e-06 0 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.06305e-06 0 1.067e-06 0 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.06905e-06 0 1.073e-06 0 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.07505e-06 0 1.079e-06 0 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.08105e-06 0 1.085e-06 0 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.08705e-06 0 1.091e-06 0 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.09305e-06 0 1.097e-06 0 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.09905e-06 0 1.103e-06 0 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.2011e-06 1 1.205e-06 1 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.2071e-06 1 1.21100000000001e-06 1 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21310000000001e-06 1 1.21700000000001e-06 1 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21910000000001e-06 1 1.22300000000001e-06 1 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22510000000001e-06 1 1.22900000000001e-06 1 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23110000000001e-06 1 1.23500000000001e-06 1 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23710000000001e-06 1 1.24100000000001e-06 1 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24310000000001e-06 1 1.24700000000001e-06 1 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44105000000001e-06 0 1.44500000000001e-06 0 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44705000000001e-06 0 1.45100000000001e-06 0 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45305000000001e-06 0 1.45700000000001e-06 0 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45905000000001e-06 0 1.46300000000002e-06 0 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46505000000002e-06 0 1.46900000000002e-06 0 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47105000000002e-06 0 1.47500000000002e-06 0 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47705000000002e-06 0 1.48100000000002e-06 0 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48305000000002e-06 0 1.48700000000002e-06 0 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58510000000002e-06 1 1.58900000000002e-06 1 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59110000000002e-06 1 1.59500000000002e-06 1 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59710000000002e-06 1 1.60100000000002e-06 1 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60310000000002e-06 1 1.60700000000002e-06 1 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60910000000002e-06 1 1.61300000000002e-06 1 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61510000000002e-06 1 1.61900000000002e-06 1 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62110000000002e-06 1 1.62500000000002e-06 1 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62710000000002e-06 1 1.63100000000002e-06 1 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82505000000003e-06 0 1.82900000000003e-06 0 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83105000000003e-06 0 1.83500000000003e-06 0 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83705000000003e-06 0 1.84100000000003e-06 0 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84305000000003e-06 0 1.84700000000003e-06 0 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84905000000003e-06 0 1.85300000000003e-06 0 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85505000000003e-06 0 1.85900000000003e-06 0 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86105000000003e-06 0 1.86500000000003e-06 0 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86705000000003e-06 0 1.87100000000003e-06 0 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96910000000003e-06 1 1.97300000000003e-06 1 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97510000000003e-06 1 1.97900000000003e-06 1 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98110000000003e-06 1 1.98500000000003e-06 1 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98710000000003e-06 1 1.99100000000003e-06 1 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99310000000003e-06 1 1.99700000000003e-06 1 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99910000000003e-06 1 2.00300000000003e-06 1 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00510000000003e-06 1 2.00900000000003e-06 1 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01110000000003e-06 1 2.01500000000003e-06 1 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20905000000003e-06 0 2.21300000000003e-06 0 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21505000000003e-06 0 2.21900000000003e-06 0 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22105000000003e-06 0 2.22500000000003e-06 0 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22705000000003e-06 0 2.23100000000003e-06 0 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23305000000003e-06 0 2.23700000000003e-06 0 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23905000000003e-06 0 2.24300000000003e-06 0 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24505000000003e-06 0 2.24900000000003e-06 0 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25105000000003e-06 0 2.25500000000003e-06 0 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35310000000003e-06 1 2.35700000000003e-06 1 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35910000000003e-06 1 2.36300000000003e-06 1 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36510000000003e-06 1 2.36900000000003e-06 1 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37110000000003e-06 1 2.37500000000003e-06 1 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37710000000003e-06 1 2.38100000000003e-06 1 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38310000000003e-06 1 2.38700000000003e-06 1 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38910000000003e-06 1 2.39300000000003e-06 1 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39510000000003e-06 1 2.39900000000003e-06 1 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59305000000004e-06 0 2.59700000000004e-06 0 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59905000000004e-06 0 2.60300000000004e-06 0 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60505000000004e-06 0 2.60900000000004e-06 0 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61105000000004e-06 0 2.61500000000004e-06 0 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61705000000004e-06 0 2.62100000000004e-06 0 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62305000000004e-06 0 2.62700000000004e-06 0 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62905000000004e-06 0 2.63300000000004e-06 0 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63505000000004e-06 0 2.63900000000004e-06 0 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73710000000004e-06 1 2.74100000000004e-06 1 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74310000000004e-06 1 2.74700000000004e-06 1 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74910000000004e-06 1 2.75300000000004e-06 1 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75510000000004e-06 1 2.75900000000004e-06 1 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76110000000004e-06 1 2.76500000000004e-06 1 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76710000000004e-06 1 2.77100000000004e-06 1 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77310000000004e-06 1 2.77700000000004e-06 1 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77910000000004e-06 1 2.78300000000004e-06 1 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97705000000004e-06 0 2.98100000000004e-06 0 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98305000000004e-06 0 2.98700000000004e-06 0 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98905000000004e-06 0 2.99300000000004e-06 0 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99505000000004e-06 0 2.99900000000004e-06 0 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00105000000004e-06 0 3.00500000000004e-06 0 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00705000000004e-06 0 3.01100000000004e-06 0 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01305000000004e-06 0 3.01700000000004e-06 0 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01905000000004e-06 0 3.02300000000004e-06 0 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_4=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.70999999999999e-08 1 1.01e-07 1 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.031e-07 1 1.07e-07 1 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.091e-07 1 1.13e-07 1 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.151e-07 1 1.19e-07 1 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.211e-07 1 1.25e-07 1 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.271e-07 1 1.31e-07 1 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.331e-07 1 1.37e-07 1 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.391e-07 1 1.43e-07 1 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.451e-07 1 1.49e-07 1 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.511e-07 1 1.55e-07 1 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.571e-07 1 1.61e-07 1 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.631e-07 1 1.67e-07 1 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.691e-07 1 1.73e-07 1 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.751e-07 1 1.79e-07 1 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.811e-07 1 1.85e-07 1 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.871e-07 1 1.91e-07 1 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.9305e-07 0 1.97e-07 0 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.9905e-07 0 2.03e-07 0 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.0505e-07 0 2.09e-07 0 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.1105e-07 0 2.15e-07 0 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.1705e-07 0 2.21e-07 0 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.2305e-07 0 2.27e-07 0 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.2905e-07 0 2.33e-07 0 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.3505e-07 0 2.39e-07 0 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.4105e-07 0 2.45e-07 0 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.4705e-07 0 2.51e-07 0 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.5305e-07 0 2.57e-07 0 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.5905e-07 0 2.63e-07 0 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.6505e-07 0 2.69e-07 0 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.7105e-07 0 2.75e-07 0 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.7705e-07 0 2.81e-07 0 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.8305e-07 0 2.87e-07 0 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81100000000001e-07 1 4.85000000000001e-07 1 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87100000000001e-07 1 4.91000000000001e-07 1 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93100000000001e-07 1 4.97000000000001e-07 1 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99100000000001e-07 1 5.03000000000001e-07 1 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05100000000001e-07 1 5.09000000000001e-07 1 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11100000000001e-07 1 5.15000000000001e-07 1 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17100000000001e-07 1 5.21e-07 1 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.231e-07 1 5.27e-07 1 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.291e-07 1 5.33e-07 1 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.351e-07 1 5.39e-07 1 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.411e-07 1 5.45e-07 1 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.471e-07 1 5.51e-07 1 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.531e-07 1 5.57e-07 1 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.591e-07 1 5.63e-07 1 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.651e-07 1 5.69e-07 1 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.711e-07 1 5.75e-07 1 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.7705e-07 0 5.81e-07 0 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.8305e-07 0 5.87e-07 0 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.8905e-07 0 5.93e-07 0 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95049999999999e-07 0 5.98999999999999e-07 0 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01049999999999e-07 0 6.04999999999999e-07 0 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07049999999999e-07 0 6.10999999999999e-07 0 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13049999999999e-07 0 6.16999999999999e-07 0 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19049999999999e-07 0 6.22999999999999e-07 0 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25049999999999e-07 0 6.28999999999999e-07 0 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31049999999999e-07 0 6.34999999999999e-07 0 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37049999999999e-07 0 6.40999999999999e-07 0 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43049999999999e-07 0 6.46999999999999e-07 0 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49049999999999e-07 0 6.52999999999999e-07 0 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55049999999999e-07 0 6.58999999999999e-07 0 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61049999999999e-07 0 6.64999999999999e-07 0 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67049999999999e-07 0 6.70999999999999e-07 0 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65099999999996e-07 1 8.68999999999996e-07 1 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71099999999996e-07 1 8.74999999999996e-07 1 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77099999999996e-07 1 8.80999999999996e-07 1 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83099999999996e-07 1 8.86999999999996e-07 1 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89099999999996e-07 1 8.92999999999996e-07 1 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95099999999996e-07 1 8.98999999999996e-07 1 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01099999999995e-07 1 9.04999999999995e-07 1 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07099999999995e-07 1 9.10999999999995e-07 1 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13099999999995e-07 1 9.16999999999995e-07 1 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19099999999995e-07 1 9.22999999999995e-07 1 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25099999999995e-07 1 9.28999999999995e-07 1 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31099999999995e-07 1 9.34999999999995e-07 1 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37099999999995e-07 1 9.40999999999995e-07 1 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43099999999995e-07 1 9.46999999999995e-07 1 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49099999999995e-07 1 9.52999999999995e-07 1 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55099999999995e-07 1 9.58999999999995e-07 1 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61049999999995e-07 0 9.64999999999995e-07 0 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67049999999995e-07 0 9.70999999999995e-07 0 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73049999999995e-07 0 9.76999999999996e-07 0 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79049999999996e-07 0 9.82999999999996e-07 0 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85049999999996e-07 0 9.88999999999996e-07 0 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91049999999996e-07 0 9.94999999999996e-07 0 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97049999999996e-07 0 1.001e-06 0 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.00305e-06 0 1.007e-06 0 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.00905e-06 0 1.013e-06 0 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.01505e-06 0 1.019e-06 0 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.02105e-06 0 1.025e-06 0 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.02705e-06 0 1.031e-06 0 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.03305e-06 0 1.037e-06 0 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.03905e-06 0 1.043e-06 0 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.04505e-06 0 1.049e-06 0 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.05105e-06 0 1.055e-06 0 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24910000000001e-06 1 1.25300000000001e-06 1 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25510000000001e-06 1 1.25900000000001e-06 1 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26110000000001e-06 1 1.26500000000001e-06 1 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26710000000001e-06 1 1.27100000000001e-06 1 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27310000000001e-06 1 1.27700000000001e-06 1 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27910000000001e-06 1 1.28300000000001e-06 1 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28510000000001e-06 1 1.28900000000001e-06 1 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29110000000001e-06 1 1.29500000000001e-06 1 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29710000000001e-06 1 1.30100000000001e-06 1 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30310000000001e-06 1 1.30700000000001e-06 1 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30910000000001e-06 1 1.31300000000001e-06 1 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31510000000001e-06 1 1.31900000000001e-06 1 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32110000000001e-06 1 1.32500000000001e-06 1 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32710000000001e-06 1 1.33100000000001e-06 1 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33310000000001e-06 1 1.33700000000001e-06 1 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33910000000001e-06 1 1.34300000000001e-06 1 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34505000000001e-06 0 1.34900000000001e-06 0 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35105000000001e-06 0 1.35500000000001e-06 0 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35705000000001e-06 0 1.36100000000001e-06 0 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36305000000001e-06 0 1.36700000000001e-06 0 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36905000000001e-06 0 1.37300000000001e-06 0 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37505000000001e-06 0 1.37900000000001e-06 0 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38105000000001e-06 0 1.38500000000001e-06 0 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38705000000001e-06 0 1.39100000000001e-06 0 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39305000000001e-06 0 1.39700000000001e-06 0 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39905000000001e-06 0 1.40300000000001e-06 0 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40505000000001e-06 0 1.40900000000001e-06 0 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41105000000001e-06 0 1.41500000000001e-06 0 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41705000000001e-06 0 1.42100000000001e-06 0 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42305000000001e-06 0 1.42700000000001e-06 0 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42905000000001e-06 0 1.43300000000001e-06 0 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43505000000001e-06 0 1.43900000000001e-06 0 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63310000000002e-06 1 1.63700000000002e-06 1 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63910000000002e-06 1 1.64300000000002e-06 1 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64510000000002e-06 1 1.64900000000002e-06 1 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65110000000002e-06 1 1.65500000000002e-06 1 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65710000000002e-06 1 1.66100000000002e-06 1 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66310000000002e-06 1 1.66700000000002e-06 1 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66910000000002e-06 1 1.67300000000002e-06 1 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67510000000002e-06 1 1.67900000000002e-06 1 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68110000000002e-06 1 1.68500000000002e-06 1 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68710000000002e-06 1 1.69100000000002e-06 1 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69310000000002e-06 1 1.69700000000002e-06 1 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69910000000002e-06 1 1.70300000000002e-06 1 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70510000000002e-06 1 1.70900000000002e-06 1 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71110000000003e-06 1 1.71500000000003e-06 1 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71710000000003e-06 1 1.72100000000003e-06 1 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72310000000003e-06 1 1.72700000000003e-06 1 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72905000000003e-06 0 1.73300000000003e-06 0 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73505000000003e-06 0 1.73900000000003e-06 0 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74105000000003e-06 0 1.74500000000003e-06 0 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74705000000003e-06 0 1.75100000000003e-06 0 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75305000000003e-06 0 1.75700000000003e-06 0 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75905000000003e-06 0 1.76300000000003e-06 0 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76505000000003e-06 0 1.76900000000003e-06 0 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77105000000003e-06 0 1.77500000000003e-06 0 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77705000000003e-06 0 1.78100000000003e-06 0 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78305000000003e-06 0 1.78700000000003e-06 0 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78905000000003e-06 0 1.79300000000003e-06 0 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79505000000003e-06 0 1.79900000000003e-06 0 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80105000000003e-06 0 1.80500000000003e-06 0 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80705000000003e-06 0 1.81100000000003e-06 0 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81305000000003e-06 0 1.81700000000003e-06 0 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81905000000003e-06 0 1.82300000000003e-06 0 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01710000000003e-06 1 2.02100000000003e-06 1 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02310000000003e-06 1 2.02700000000003e-06 1 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02910000000003e-06 1 2.03300000000003e-06 1 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03510000000003e-06 1 2.03900000000003e-06 1 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04110000000003e-06 1 2.04500000000003e-06 1 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04710000000003e-06 1 2.05100000000003e-06 1 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05310000000003e-06 1 2.05700000000003e-06 1 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05910000000003e-06 1 2.06300000000003e-06 1 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06510000000003e-06 1 2.06900000000003e-06 1 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07110000000003e-06 1 2.07500000000003e-06 1 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07710000000003e-06 1 2.08100000000003e-06 1 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08310000000003e-06 1 2.08700000000003e-06 1 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08910000000003e-06 1 2.09300000000003e-06 1 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09510000000003e-06 1 2.09900000000003e-06 1 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10110000000003e-06 1 2.10500000000003e-06 1 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10710000000003e-06 1 2.11100000000003e-06 1 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11305000000003e-06 0 2.11700000000003e-06 0 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11905000000003e-06 0 2.12300000000003e-06 0 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12505000000003e-06 0 2.12900000000003e-06 0 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13105000000003e-06 0 2.13500000000003e-06 0 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13705000000003e-06 0 2.14100000000003e-06 0 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14305000000003e-06 0 2.14700000000003e-06 0 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14905000000003e-06 0 2.15300000000003e-06 0 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15505000000003e-06 0 2.15900000000003e-06 0 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16105000000003e-06 0 2.16500000000003e-06 0 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16705000000003e-06 0 2.17100000000003e-06 0 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17305000000003e-06 0 2.17700000000003e-06 0 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17905000000003e-06 0 2.18300000000003e-06 0 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18505000000003e-06 0 2.18900000000003e-06 0 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19105000000003e-06 0 2.19500000000003e-06 0 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19705000000003e-06 0 2.20100000000003e-06 0 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20305000000003e-06 0 2.20700000000003e-06 0 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40110000000003e-06 1 2.40500000000003e-06 1 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40710000000003e-06 1 2.41100000000004e-06 1 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41310000000003e-06 1 2.41700000000004e-06 1 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41910000000003e-06 1 2.42300000000004e-06 1 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42510000000004e-06 1 2.42900000000004e-06 1 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43110000000004e-06 1 2.43500000000004e-06 1 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43710000000004e-06 1 2.44100000000004e-06 1 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44310000000004e-06 1 2.44700000000004e-06 1 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44910000000004e-06 1 2.45300000000004e-06 1 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45510000000004e-06 1 2.45900000000004e-06 1 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46110000000004e-06 1 2.46500000000004e-06 1 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46710000000004e-06 1 2.47100000000004e-06 1 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47310000000004e-06 1 2.47700000000004e-06 1 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47910000000004e-06 1 2.48300000000004e-06 1 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48510000000004e-06 1 2.48900000000004e-06 1 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49110000000004e-06 1 2.49500000000004e-06 1 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49705000000004e-06 0 2.50100000000004e-06 0 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50305000000004e-06 0 2.50700000000004e-06 0 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50905000000004e-06 0 2.51300000000004e-06 0 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51505000000004e-06 0 2.51900000000004e-06 0 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52105000000004e-06 0 2.52500000000004e-06 0 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52705000000004e-06 0 2.53100000000004e-06 0 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53305000000004e-06 0 2.53700000000004e-06 0 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53905000000004e-06 0 2.54300000000004e-06 0 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54505000000004e-06 0 2.54900000000004e-06 0 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55105000000004e-06 0 2.55500000000004e-06 0 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55705000000004e-06 0 2.56100000000004e-06 0 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56305000000004e-06 0 2.56700000000004e-06 0 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56905000000004e-06 0 2.57300000000004e-06 0 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57505000000004e-06 0 2.57900000000004e-06 0 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58105000000004e-06 0 2.58500000000004e-06 0 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58705000000004e-06 0 2.59100000000004e-06 0 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78510000000004e-06 1 2.78900000000004e-06 1 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79110000000004e-06 1 2.79500000000004e-06 1 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79710000000004e-06 1 2.80100000000004e-06 1 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80310000000004e-06 1 2.80700000000004e-06 1 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80910000000004e-06 1 2.81300000000004e-06 1 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81510000000004e-06 1 2.81900000000004e-06 1 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82110000000004e-06 1 2.82500000000004e-06 1 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82710000000004e-06 1 2.83100000000004e-06 1 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83310000000004e-06 1 2.83700000000004e-06 1 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83910000000004e-06 1 2.84300000000004e-06 1 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84510000000004e-06 1 2.84900000000004e-06 1 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85110000000004e-06 1 2.85500000000004e-06 1 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85710000000004e-06 1 2.86100000000004e-06 1 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86310000000004e-06 1 2.86700000000004e-06 1 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86910000000004e-06 1 2.87300000000004e-06 1 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87510000000004e-06 1 2.87900000000004e-06 1 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88105000000004e-06 0 2.88500000000004e-06 0 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88705000000004e-06 0 2.89100000000004e-06 0 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89305000000004e-06 0 2.89700000000004e-06 0 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89905000000004e-06 0 2.90300000000004e-06 0 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90505000000004e-06 0 2.90900000000004e-06 0 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91105000000004e-06 0 2.91500000000004e-06 0 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91705000000004e-06 0 2.92100000000004e-06 0 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92305000000004e-06 0 2.92700000000004e-06 0 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92905000000004e-06 0 2.93300000000004e-06 0 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93505000000004e-06 0 2.93900000000004e-06 0 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94105000000004e-06 0 2.94500000000004e-06 0 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94705000000004e-06 0 2.95100000000004e-06 0 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95305000000004e-06 0 2.95700000000004e-06 0 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95905000000004e-06 0 2.96300000000004e-06 0 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96505000000004e-06 0 2.96900000000004e-06 0 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97105000000004e-06 0 2.97500000000004e-06 0 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters waveWLstart_5=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 9.6e-08 0 9.605e-08 0 9.7e-08 0 9.705e-08 0 1.01e-07 0 1.0105e-07 0 1.02e-07 0 1.0205e-07 0 1.03e-07 0 1.0305e-07 0 1.07e-07 0 1.0705e-07 0 1.08e-07 0 1.0805e-07 0 1.09e-07 0 1.0905e-07 0 1.13e-07 0 1.1305e-07 0 1.14e-07 0 1.1405e-07 0 1.15e-07 0 1.1505e-07 0 1.19e-07 0 1.1905e-07 0 1.2e-07 0 1.2005e-07 0 1.21e-07 0 1.2105e-07 0 1.25e-07 0 1.2505e-07 0 1.26e-07 0 1.2605e-07 0 1.27e-07 0 1.2705e-07 0 1.31e-07 0 1.3105e-07 0 1.32e-07 0 1.3205e-07 0 1.33e-07 0 1.3305e-07 0 1.37e-07 0 1.3705e-07 0 1.38e-07 0 1.3805e-07 0 1.39e-07 0 1.3905e-07 0 1.43e-07 0 1.4305e-07 0 1.44e-07 0 1.4405e-07 0 1.45e-07 0 1.4505e-07 0 1.49e-07 0 1.4905e-07 0 1.5e-07 0 1.5005e-07 0 1.51e-07 0 1.5105e-07 0 1.55e-07 0 1.5505e-07 0 1.56e-07 0 1.5605e-07 0 1.57e-07 0 1.5705e-07 0 1.61e-07 0 1.6105e-07 0 1.62e-07 0 1.6205e-07 0 1.63e-07 0 1.6305e-07 0 1.67e-07 0 1.6705e-07 0 1.68e-07 0 1.6805e-07 0 1.69e-07 0 1.6905e-07 0 1.73e-07 0 1.7305e-07 0 1.74e-07 0 1.7405e-07 0 1.75e-07 0 1.7505e-07 0 1.79e-07 0 1.7905e-07 0 1.8e-07 0 1.8005e-07 0 1.81e-07 0 1.8105e-07 0 1.85e-07 0 1.8505e-07 0 1.86e-07 0 1.8605e-07 0 1.87e-07 0 1.8705e-07 0 1.91e-07 0 1.9105e-07 0 1.92e-07 0 1.9205e-07 0 1.93e-07 0 1.931e-07 1 1.97e-07 1 1.9705e-07 0 1.98e-07 0 1.9805e-07 0 1.99e-07 0 1.991e-07 1 2.03e-07 1 2.0305e-07 0 2.04e-07 0 2.0405e-07 0 2.05e-07 0 2.051e-07 1 2.09e-07 1 2.0905e-07 0 2.1e-07 0 2.1005e-07 0 2.11e-07 0 2.111e-07 1 2.15e-07 1 2.1505e-07 0 2.16e-07 0 2.1605e-07 0 2.17e-07 0 2.171e-07 1 2.21e-07 1 2.2105e-07 0 2.22e-07 0 2.2205e-07 0 2.23e-07 0 2.231e-07 1 2.27e-07 1 2.2705e-07 0 2.28e-07 0 2.2805e-07 0 2.29e-07 0 2.291e-07 1 2.33e-07 1 2.3305e-07 0 2.34e-07 0 2.3405e-07 0 2.35e-07 0 2.351e-07 1 2.39e-07 1 2.3905e-07 0 2.4e-07 0 2.4005e-07 0 2.41e-07 0 2.411e-07 1 2.45e-07 1 2.4505e-07 0 2.46e-07 0 2.4605e-07 0 2.47e-07 0 2.471e-07 1 2.51e-07 1 2.5105e-07 0 2.52e-07 0 2.5205e-07 0 2.53e-07 0 2.531e-07 1 2.57e-07 1 2.5705e-07 0 2.58e-07 0 2.5805e-07 0 2.59e-07 0 2.591e-07 1 2.63e-07 1 2.6305e-07 0 2.64e-07 0 2.6405e-07 0 2.65e-07 0 2.651e-07 1 2.69e-07 1 2.6905e-07 0 2.7e-07 0 2.7005e-07 0 2.71e-07 0 2.711e-07 1 2.75e-07 1 2.7505e-07 0 2.76e-07 0 2.7605e-07 0 2.77e-07 0 2.771e-07 1 2.81e-07 1 2.8105e-07 0 2.82e-07 0 2.8205e-07 0 2.83e-07 0 2.831e-07 1 2.87e-07 1 2.8705e-07 0 2.88e-07 0 2.8805e-07 0 2.89e-07 0 2.891e-07 1 2.93e-07 1 2.9305e-07 0 2.94e-07 0 2.9405e-07 0 2.95e-07 0 2.951e-07 1 2.99e-07 1 2.9905e-07 0 3e-07 0 3.0005e-07 0 3.01e-07 0 3.011e-07 1 3.05e-07 1 3.0505e-07 0 3.06e-07 0 3.0605e-07 0 3.07e-07 0 3.071e-07 1 3.11e-07 1 3.1105e-07 0 3.12e-07 0 3.1205e-07 0 3.13e-07 0 3.131e-07 1 3.17e-07 1 3.1705e-07 0 3.18e-07 0 3.1805e-07 0 3.19e-07 0 3.191e-07 1 3.23e-07 1 3.2305e-07 0 3.24e-07 0 3.2405e-07 0 3.25e-07 0 3.251e-07 1 3.29e-07 1 3.2905e-07 0 3.3e-07 0 3.3005e-07 0 3.31e-07 0 3.311e-07 1 3.35e-07 1 3.3505e-07 0 3.36e-07 0 3.3605e-07 0 3.37e-07 0 3.371e-07 1 3.41e-07 1 3.4105e-07 0 3.42e-07 0 3.4205e-07 0 3.43e-07 0 3.431e-07 1 3.47e-07 1 3.4705e-07 0 3.48e-07 0 3.4805e-07 0 3.49e-07 0 3.491e-07 1 3.53e-07 1 3.5305e-07 0 3.54e-07 0 3.5405e-07 0 3.55e-07 0 3.551e-07 1 3.59e-07 1 3.5905e-07 0 3.6e-07 0 3.6005e-07 0 3.61e-07 0 3.61100000000001e-07 1 3.65e-07 1 3.6505e-07 0 3.66e-07 0 3.66050000000001e-07 0 3.67000000000001e-07 0 3.67100000000001e-07 1 3.71000000000001e-07 1 3.71050000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.73000000000001e-07 0 3.73100000000001e-07 1 3.77000000000001e-07 1 3.77050000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.79000000000001e-07 0 3.79100000000001e-07 1 3.83000000000001e-07 1 3.83050000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.85000000000001e-07 0 3.85050000000001e-07 0 3.89000000000001e-07 0 3.89050000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.91000000000001e-07 0 3.91050000000001e-07 0 3.95000000000001e-07 0 3.95050000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 3.97000000000001e-07 0 3.97050000000001e-07 0 4.01000000000001e-07 0 4.01050000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.03000000000001e-07 0 4.03050000000001e-07 0 4.07000000000001e-07 0 4.07050000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.09000000000001e-07 0 4.09050000000001e-07 0 4.13000000000001e-07 0 4.13050000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.15000000000001e-07 0 4.15050000000001e-07 0 4.19000000000001e-07 0 4.19050000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.21000000000001e-07 0 4.21050000000001e-07 0 4.25000000000001e-07 0 4.25050000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.27000000000001e-07 0 4.27050000000001e-07 0 4.31000000000001e-07 0 4.31050000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.33000000000001e-07 0 4.33050000000001e-07 0 4.37000000000001e-07 0 4.37050000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.39000000000001e-07 0 4.39050000000001e-07 0 4.43000000000001e-07 0 4.43050000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.45000000000001e-07 0 4.45050000000001e-07 0 4.49000000000001e-07 0 4.49050000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.51000000000001e-07 0 4.51050000000001e-07 0 4.55000000000001e-07 0 4.55050000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.57000000000001e-07 0 4.57050000000001e-07 0 4.61000000000001e-07 0 4.61050000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.63000000000001e-07 0 4.63050000000001e-07 0 4.67000000000001e-07 0 4.67050000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.69000000000001e-07 0 4.69050000000001e-07 0 4.73000000000001e-07 0 4.73050000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.75000000000001e-07 0 4.75050000000001e-07 0 4.79000000000001e-07 0 4.79050000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.81000000000001e-07 0 4.81050000000001e-07 0 4.85000000000001e-07 0 4.85050000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.87000000000001e-07 0 4.87050000000001e-07 0 4.91000000000001e-07 0 4.91050000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.93000000000001e-07 0 4.93050000000001e-07 0 4.97000000000001e-07 0 4.97050000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 4.99000000000001e-07 0 4.99050000000001e-07 0 5.03000000000001e-07 0 5.03050000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.05000000000001e-07 0 5.05050000000001e-07 0 5.09000000000001e-07 0 5.09050000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.11000000000001e-07 0 5.11050000000001e-07 0 5.15000000000001e-07 0 5.15050000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.17000000000001e-07 0 5.17050000000001e-07 0 5.21e-07 0 5.21050000000001e-07 0 5.22e-07 0 5.2205e-07 0 5.23e-07 0 5.2305e-07 0 5.27e-07 0 5.2705e-07 0 5.28e-07 0 5.2805e-07 0 5.29e-07 0 5.2905e-07 0 5.33e-07 0 5.3305e-07 0 5.34e-07 0 5.3405e-07 0 5.35e-07 0 5.3505e-07 0 5.39e-07 0 5.3905e-07 0 5.4e-07 0 5.4005e-07 0 5.41e-07 0 5.4105e-07 0 5.45e-07 0 5.4505e-07 0 5.46e-07 0 5.4605e-07 0 5.47e-07 0 5.4705e-07 0 5.51e-07 0 5.5105e-07 0 5.52e-07 0 5.5205e-07 0 5.53e-07 0 5.5305e-07 0 5.57e-07 0 5.5705e-07 0 5.58e-07 0 5.5805e-07 0 5.59e-07 0 5.5905e-07 0 5.63e-07 0 5.6305e-07 0 5.64e-07 0 5.6405e-07 0 5.65e-07 0 5.6505e-07 0 5.69e-07 0 5.6905e-07 0 5.7e-07 0 5.7005e-07 0 5.71e-07 0 5.7105e-07 0 5.75e-07 0 5.7505e-07 0 5.76e-07 0 5.7605e-07 0 5.77e-07 0 5.771e-07 1 5.81e-07 1 5.8105e-07 0 5.82e-07 0 5.8205e-07 0 5.83e-07 0 5.831e-07 1 5.87e-07 1 5.8705e-07 0 5.88e-07 0 5.8805e-07 0 5.89e-07 0 5.891e-07 1 5.93e-07 1 5.9305e-07 0 5.94e-07 0 5.9405e-07 0 5.94999999999999e-07 0 5.95099999999999e-07 1 5.98999999999999e-07 1 5.99049999999999e-07 0 5.99999999999999e-07 0 6.00049999999999e-07 0 6.00999999999999e-07 0 6.01099999999999e-07 1 6.04999999999999e-07 1 6.05049999999999e-07 0 6.05999999999999e-07 0 6.06049999999999e-07 0 6.06999999999999e-07 0 6.07099999999999e-07 1 6.10999999999999e-07 1 6.11049999999999e-07 0 6.11999999999999e-07 0 6.12049999999999e-07 0 6.12999999999999e-07 0 6.13099999999999e-07 1 6.16999999999999e-07 1 6.17049999999999e-07 0 6.17999999999999e-07 0 6.18049999999999e-07 0 6.18999999999999e-07 0 6.19099999999999e-07 1 6.22999999999999e-07 1 6.23049999999999e-07 0 6.23999999999999e-07 0 6.24049999999999e-07 0 6.24999999999999e-07 0 6.25099999999999e-07 1 6.28999999999999e-07 1 6.29049999999999e-07 0 6.29999999999999e-07 0 6.30049999999999e-07 0 6.30999999999999e-07 0 6.31099999999999e-07 1 6.34999999999999e-07 1 6.35049999999999e-07 0 6.35999999999999e-07 0 6.36049999999999e-07 0 6.36999999999999e-07 0 6.37099999999999e-07 1 6.40999999999999e-07 1 6.41049999999999e-07 0 6.41999999999999e-07 0 6.42049999999999e-07 0 6.42999999999999e-07 0 6.43099999999999e-07 1 6.46999999999999e-07 1 6.47049999999999e-07 0 6.47999999999999e-07 0 6.48049999999999e-07 0 6.48999999999999e-07 0 6.49099999999999e-07 1 6.52999999999999e-07 1 6.53049999999999e-07 0 6.53999999999999e-07 0 6.54049999999999e-07 0 6.54999999999999e-07 0 6.55099999999999e-07 1 6.58999999999999e-07 1 6.59049999999999e-07 0 6.59999999999999e-07 0 6.60049999999999e-07 0 6.60999999999999e-07 0 6.61099999999999e-07 1 6.64999999999999e-07 1 6.65049999999999e-07 0 6.65999999999999e-07 0 6.66049999999999e-07 0 6.66999999999999e-07 0 6.67099999999999e-07 1 6.70999999999999e-07 1 6.71049999999999e-07 0 6.71999999999998e-07 0 6.72049999999999e-07 0 6.72999999999998e-07 0 6.73099999999998e-07 1 6.76999999999998e-07 1 6.77049999999998e-07 0 6.77999999999998e-07 0 6.78049999999998e-07 0 6.78999999999998e-07 0 6.79099999999998e-07 1 6.82999999999998e-07 1 6.83049999999998e-07 0 6.83999999999998e-07 0 6.84049999999998e-07 0 6.84999999999998e-07 0 6.85099999999998e-07 1 6.88999999999998e-07 1 6.89049999999998e-07 0 6.89999999999998e-07 0 6.90049999999998e-07 0 6.90999999999998e-07 0 6.91099999999998e-07 1 6.94999999999998e-07 1 6.95049999999998e-07 0 6.95999999999998e-07 0 6.96049999999998e-07 0 6.96999999999998e-07 0 6.97099999999998e-07 1 7.00999999999998e-07 1 7.01049999999998e-07 0 7.01999999999998e-07 0 7.02049999999998e-07 0 7.02999999999998e-07 0 7.03099999999998e-07 1 7.06999999999998e-07 1 7.07049999999998e-07 0 7.07999999999998e-07 0 7.08049999999998e-07 0 7.08999999999998e-07 0 7.09099999999998e-07 1 7.12999999999998e-07 1 7.13049999999998e-07 0 7.13999999999998e-07 0 7.14049999999998e-07 0 7.14999999999998e-07 0 7.15099999999998e-07 1 7.18999999999998e-07 1 7.19049999999998e-07 0 7.19999999999998e-07 0 7.20049999999998e-07 0 7.20999999999998e-07 0 7.21099999999998e-07 1 7.24999999999998e-07 1 7.25049999999998e-07 0 7.25999999999998e-07 0 7.26049999999998e-07 0 7.26999999999998e-07 0 7.27099999999998e-07 1 7.30999999999998e-07 1 7.31049999999998e-07 0 7.31999999999998e-07 0 7.32049999999998e-07 0 7.32999999999998e-07 0 7.33099999999998e-07 1 7.36999999999998e-07 1 7.37049999999998e-07 0 7.37999999999998e-07 0 7.38049999999998e-07 0 7.38999999999998e-07 0 7.39099999999998e-07 1 7.42999999999998e-07 1 7.43049999999998e-07 0 7.43999999999998e-07 0 7.44049999999998e-07 0 7.44999999999998e-07 0 7.45099999999998e-07 1 7.48999999999998e-07 1 7.49049999999998e-07 0 7.49999999999997e-07 0 7.50049999999997e-07 0 7.50999999999997e-07 0 7.51099999999997e-07 1 7.54999999999997e-07 1 7.55049999999997e-07 0 7.55999999999997e-07 0 7.56049999999997e-07 0 7.56999999999997e-07 0 7.57099999999997e-07 1 7.60999999999997e-07 1 7.61049999999997e-07 0 7.61999999999997e-07 0 7.62049999999997e-07 0 7.62999999999997e-07 0 7.63099999999997e-07 1 7.66999999999997e-07 1 7.67049999999997e-07 0 7.67999999999997e-07 0 7.68049999999997e-07 0 7.68999999999997e-07 0 7.69049999999997e-07 0 7.72999999999997e-07 0 7.73049999999997e-07 0 7.73999999999997e-07 0 7.74049999999997e-07 0 7.74999999999997e-07 0 7.75049999999997e-07 0 7.78999999999997e-07 0 7.79049999999997e-07 0 7.79999999999997e-07 0 7.80049999999997e-07 0 7.80999999999997e-07 0 7.81049999999997e-07 0 7.84999999999997e-07 0 7.85049999999997e-07 0 7.85999999999997e-07 0 7.86049999999997e-07 0 7.86999999999997e-07 0 7.87049999999997e-07 0 7.90999999999997e-07 0 7.91049999999997e-07 0 7.91999999999997e-07 0 7.92049999999997e-07 0 7.92999999999997e-07 0 7.93049999999997e-07 0 7.96999999999997e-07 0 7.97049999999997e-07 0 7.97999999999997e-07 0 7.98049999999997e-07 0 7.98999999999997e-07 0 7.99049999999997e-07 0 8.02999999999997e-07 0 8.03049999999997e-07 0 8.03999999999997e-07 0 8.04049999999997e-07 0 8.04999999999997e-07 0 8.05049999999997e-07 0 8.08999999999997e-07 0 8.09049999999997e-07 0 8.09999999999997e-07 0 8.10049999999997e-07 0 8.10999999999997e-07 0 8.11049999999997e-07 0 8.14999999999997e-07 0 8.15049999999997e-07 0 8.15999999999997e-07 0 8.16049999999997e-07 0 8.16999999999997e-07 0 8.17049999999997e-07 0 8.20999999999997e-07 0 8.21049999999997e-07 0 8.21999999999997e-07 0 8.22049999999997e-07 0 8.22999999999997e-07 0 8.23049999999997e-07 0 8.26999999999996e-07 0 8.27049999999996e-07 0 8.27999999999996e-07 0 8.28049999999996e-07 0 8.28999999999996e-07 0 8.29049999999996e-07 0 8.32999999999996e-07 0 8.33049999999996e-07 0 8.33999999999996e-07 0 8.34049999999996e-07 0 8.34999999999996e-07 0 8.35049999999996e-07 0 8.38999999999996e-07 0 8.39049999999996e-07 0 8.39999999999996e-07 0 8.40049999999996e-07 0 8.40999999999996e-07 0 8.41049999999996e-07 0 8.44999999999996e-07 0 8.45049999999996e-07 0 8.45999999999996e-07 0 8.46049999999996e-07 0 8.46999999999996e-07 0 8.47049999999996e-07 0 8.50999999999996e-07 0 8.51049999999996e-07 0 8.51999999999996e-07 0 8.52049999999996e-07 0 8.52999999999996e-07 0 8.53049999999996e-07 0 8.56999999999996e-07 0 8.57049999999996e-07 0 8.57999999999996e-07 0 8.58049999999996e-07 0 8.58999999999996e-07 0 8.59049999999996e-07 0 8.62999999999996e-07 0 8.63049999999996e-07 0 8.63999999999996e-07 0 8.64049999999996e-07 0 8.64999999999996e-07 0 8.65049999999996e-07 0 8.68999999999996e-07 0 8.69049999999996e-07 0 8.69999999999996e-07 0 8.70049999999996e-07 0 8.70999999999996e-07 0 8.71049999999996e-07 0 8.74999999999996e-07 0 8.75049999999996e-07 0 8.75999999999996e-07 0 8.76049999999996e-07 0 8.76999999999996e-07 0 8.77049999999996e-07 0 8.80999999999996e-07 0 8.81049999999996e-07 0 8.81999999999996e-07 0 8.82049999999996e-07 0 8.82999999999996e-07 0 8.83049999999996e-07 0 8.86999999999996e-07 0 8.87049999999996e-07 0 8.87999999999996e-07 0 8.88049999999996e-07 0 8.88999999999996e-07 0 8.89049999999996e-07 0 8.92999999999996e-07 0 8.93049999999996e-07 0 8.93999999999996e-07 0 8.94049999999996e-07 0 8.94999999999996e-07 0 8.95049999999996e-07 0 8.98999999999996e-07 0 8.99049999999996e-07 0 8.99999999999996e-07 0 9.00049999999996e-07 0 9.00999999999995e-07 0 9.01049999999995e-07 0 9.04999999999995e-07 0 9.05049999999995e-07 0 9.05999999999995e-07 0 9.06049999999995e-07 0 9.06999999999995e-07 0 9.07049999999995e-07 0 9.10999999999995e-07 0 9.11049999999995e-07 0 9.11999999999995e-07 0 9.12049999999995e-07 0 9.12999999999995e-07 0 9.13049999999995e-07 0 9.16999999999995e-07 0 9.17049999999995e-07 0 9.17999999999995e-07 0 9.18049999999995e-07 0 9.18999999999995e-07 0 9.19049999999995e-07 0 9.22999999999995e-07 0 9.23049999999995e-07 0 9.23999999999995e-07 0 9.24049999999995e-07 0 9.24999999999995e-07 0 9.25049999999995e-07 0 9.28999999999995e-07 0 9.29049999999995e-07 0 9.29999999999995e-07 0 9.30049999999995e-07 0 9.30999999999995e-07 0 9.31049999999995e-07 0 9.34999999999995e-07 0 9.35049999999995e-07 0 9.35999999999995e-07 0 9.36049999999995e-07 0 9.36999999999995e-07 0 9.37049999999995e-07 0 9.40999999999995e-07 0 9.41049999999995e-07 0 9.41999999999995e-07 0 9.42049999999995e-07 0 9.42999999999995e-07 0 9.43049999999995e-07 0 9.46999999999995e-07 0 9.47049999999995e-07 0 9.47999999999995e-07 0 9.48049999999995e-07 0 9.48999999999995e-07 0 9.49049999999995e-07 0 9.52999999999995e-07 0 9.53049999999995e-07 0 9.53999999999995e-07 0 9.54049999999995e-07 0 9.54999999999995e-07 0 9.55049999999995e-07 0 9.58999999999995e-07 0 9.59049999999995e-07 0 9.59999999999995e-07 0 9.60049999999995e-07 0 9.60999999999995e-07 0 9.61099999999995e-07 1 9.64999999999995e-07 1 9.65049999999995e-07 0 9.65999999999995e-07 0 9.66049999999995e-07 0 9.66999999999995e-07 0 9.67099999999995e-07 1 9.70999999999995e-07 1 9.71049999999995e-07 0 9.71999999999996e-07 0 9.72049999999995e-07 0 9.72999999999996e-07 0 9.73099999999996e-07 1 9.76999999999996e-07 1 9.77049999999996e-07 0 9.77999999999996e-07 0 9.78049999999996e-07 0 9.78999999999996e-07 0 9.79099999999996e-07 1 9.82999999999996e-07 1 9.83049999999996e-07 0 9.83999999999996e-07 0 9.84049999999996e-07 0 9.84999999999996e-07 0 9.85099999999996e-07 1 9.88999999999996e-07 1 9.89049999999996e-07 0 9.89999999999996e-07 0 9.90049999999996e-07 0 9.90999999999996e-07 0 9.91099999999996e-07 1 9.94999999999996e-07 1 9.95049999999996e-07 0 9.95999999999996e-07 0 9.96049999999996e-07 0 9.96999999999997e-07 0 9.97099999999997e-07 1 1.001e-06 1 1.00105e-06 0 1.002e-06 0 1.00205e-06 0 1.003e-06 0 1.0031e-06 1 1.007e-06 1 1.00705e-06 0 1.008e-06 0 1.00805e-06 0 1.009e-06 0 1.0091e-06 1 1.013e-06 1 1.01305e-06 0 1.014e-06 0 1.01405e-06 0 1.015e-06 0 1.0151e-06 1 1.019e-06 1 1.01905e-06 0 1.02e-06 0 1.02005e-06 0 1.021e-06 0 1.0211e-06 1 1.025e-06 1 1.02505e-06 0 1.026e-06 0 1.02605e-06 0 1.027e-06 0 1.0271e-06 1 1.031e-06 1 1.03105e-06 0 1.032e-06 0 1.03205e-06 0 1.033e-06 0 1.0331e-06 1 1.037e-06 1 1.03705e-06 0 1.038e-06 0 1.03805e-06 0 1.039e-06 0 1.0391e-06 1 1.043e-06 1 1.04305e-06 0 1.044e-06 0 1.04405e-06 0 1.045e-06 0 1.0451e-06 1 1.049e-06 1 1.04905e-06 0 1.05e-06 0 1.05005e-06 0 1.051e-06 0 1.0511e-06 1 1.055e-06 1 1.05505e-06 0 1.056e-06 0 1.05605e-06 0 1.057e-06 0 1.0571e-06 1 1.061e-06 1 1.06105e-06 0 1.062e-06 0 1.06205e-06 0 1.063e-06 0 1.0631e-06 1 1.067e-06 1 1.06705e-06 0 1.068e-06 0 1.06805e-06 0 1.069e-06 0 1.0691e-06 1 1.073e-06 1 1.07305e-06 0 1.074e-06 0 1.07405e-06 0 1.075e-06 0 1.0751e-06 1 1.079e-06 1 1.07905e-06 0 1.08e-06 0 1.08005e-06 0 1.081e-06 0 1.0811e-06 1 1.085e-06 1 1.08505e-06 0 1.086e-06 0 1.08605e-06 0 1.087e-06 0 1.0871e-06 1 1.091e-06 1 1.09105e-06 0 1.092e-06 0 1.09205e-06 0 1.093e-06 0 1.0931e-06 1 1.097e-06 1 1.09705e-06 0 1.098e-06 0 1.09805e-06 0 1.099e-06 0 1.0991e-06 1 1.103e-06 1 1.10305e-06 0 1.104e-06 0 1.10405e-06 0 1.105e-06 0 1.1051e-06 1 1.109e-06 1 1.10905e-06 0 1.11e-06 0 1.11005e-06 0 1.111e-06 0 1.1111e-06 1 1.115e-06 1 1.11505e-06 0 1.116e-06 0 1.11605e-06 0 1.117e-06 0 1.1171e-06 1 1.121e-06 1 1.12105e-06 0 1.122e-06 0 1.12205e-06 0 1.123e-06 0 1.1231e-06 1 1.127e-06 1 1.12705e-06 0 1.128e-06 0 1.12805e-06 0 1.129e-06 0 1.1291e-06 1 1.133e-06 1 1.13305e-06 0 1.134e-06 0 1.13405e-06 0 1.135e-06 0 1.1351e-06 1 1.139e-06 1 1.13905e-06 0 1.14e-06 0 1.14005e-06 0 1.141e-06 0 1.1411e-06 1 1.145e-06 1 1.14505e-06 0 1.146e-06 0 1.14605e-06 0 1.147e-06 0 1.1471e-06 1 1.151e-06 1 1.15105e-06 0 1.152e-06 0 1.15205e-06 0 1.153e-06 0 1.15305e-06 0 1.157e-06 0 1.15705e-06 0 1.158e-06 0 1.15805e-06 0 1.159e-06 0 1.15905e-06 0 1.163e-06 0 1.16305e-06 0 1.164e-06 0 1.16405e-06 0 1.165e-06 0 1.16505e-06 0 1.169e-06 0 1.16905e-06 0 1.17e-06 0 1.17005e-06 0 1.171e-06 0 1.17105e-06 0 1.175e-06 0 1.17505e-06 0 1.176e-06 0 1.17605e-06 0 1.177e-06 0 1.17705e-06 0 1.181e-06 0 1.18105e-06 0 1.182e-06 0 1.18205e-06 0 1.183e-06 0 1.18305e-06 0 1.187e-06 0 1.18705e-06 0 1.188e-06 0 1.18805e-06 0 1.189e-06 0 1.18905e-06 0 1.193e-06 0 1.19305e-06 0 1.194e-06 0 1.19405e-06 0 1.195e-06 0 1.19505e-06 0 1.199e-06 0 1.19905e-06 0 1.2e-06 0 1.20005e-06 0 1.201e-06 0 1.20105e-06 0 1.205e-06 0 1.20505e-06 0 1.206e-06 0 1.20605e-06 0 1.207e-06 0 1.20705e-06 0 1.21100000000001e-06 0 1.21105e-06 0 1.21200000000001e-06 0 1.21205e-06 0 1.21300000000001e-06 0 1.21305000000001e-06 0 1.21700000000001e-06 0 1.21705000000001e-06 0 1.21800000000001e-06 0 1.21805000000001e-06 0 1.21900000000001e-06 0 1.21905000000001e-06 0 1.22300000000001e-06 0 1.22305000000001e-06 0 1.22400000000001e-06 0 1.22405000000001e-06 0 1.22500000000001e-06 0 1.22505000000001e-06 0 1.22900000000001e-06 0 1.22905000000001e-06 0 1.23000000000001e-06 0 1.23005000000001e-06 0 1.23100000000001e-06 0 1.23105000000001e-06 0 1.23500000000001e-06 0 1.23505000000001e-06 0 1.23600000000001e-06 0 1.23605000000001e-06 0 1.23700000000001e-06 0 1.23705000000001e-06 0 1.24100000000001e-06 0 1.24105000000001e-06 0 1.24200000000001e-06 0 1.24205000000001e-06 0 1.24300000000001e-06 0 1.24305000000001e-06 0 1.24700000000001e-06 0 1.24705000000001e-06 0 1.24800000000001e-06 0 1.24805000000001e-06 0 1.24900000000001e-06 0 1.24905000000001e-06 0 1.25300000000001e-06 0 1.25305000000001e-06 0 1.25400000000001e-06 0 1.25405000000001e-06 0 1.25500000000001e-06 0 1.25505000000001e-06 0 1.25900000000001e-06 0 1.25905000000001e-06 0 1.26000000000001e-06 0 1.26005000000001e-06 0 1.26100000000001e-06 0 1.26105000000001e-06 0 1.26500000000001e-06 0 1.26505000000001e-06 0 1.26600000000001e-06 0 1.26605000000001e-06 0 1.26700000000001e-06 0 1.26705000000001e-06 0 1.27100000000001e-06 0 1.27105000000001e-06 0 1.27200000000001e-06 0 1.27205000000001e-06 0 1.27300000000001e-06 0 1.27305000000001e-06 0 1.27700000000001e-06 0 1.27705000000001e-06 0 1.27800000000001e-06 0 1.27805000000001e-06 0 1.27900000000001e-06 0 1.27905000000001e-06 0 1.28300000000001e-06 0 1.28305000000001e-06 0 1.28400000000001e-06 0 1.28405000000001e-06 0 1.28500000000001e-06 0 1.28505000000001e-06 0 1.28900000000001e-06 0 1.28905000000001e-06 0 1.29000000000001e-06 0 1.29005000000001e-06 0 1.29100000000001e-06 0 1.29105000000001e-06 0 1.29500000000001e-06 0 1.29505000000001e-06 0 1.29600000000001e-06 0 1.29605000000001e-06 0 1.29700000000001e-06 0 1.29705000000001e-06 0 1.30100000000001e-06 0 1.30105000000001e-06 0 1.30200000000001e-06 0 1.30205000000001e-06 0 1.30300000000001e-06 0 1.30305000000001e-06 0 1.30700000000001e-06 0 1.30705000000001e-06 0 1.30800000000001e-06 0 1.30805000000001e-06 0 1.30900000000001e-06 0 1.30905000000001e-06 0 1.31300000000001e-06 0 1.31305000000001e-06 0 1.31400000000001e-06 0 1.31405000000001e-06 0 1.31500000000001e-06 0 1.31505000000001e-06 0 1.31900000000001e-06 0 1.31905000000001e-06 0 1.32000000000001e-06 0 1.32005000000001e-06 0 1.32100000000001e-06 0 1.32105000000001e-06 0 1.32500000000001e-06 0 1.32505000000001e-06 0 1.32600000000001e-06 0 1.32605000000001e-06 0 1.32700000000001e-06 0 1.32705000000001e-06 0 1.33100000000001e-06 0 1.33105000000001e-06 0 1.33200000000001e-06 0 1.33205000000001e-06 0 1.33300000000001e-06 0 1.33305000000001e-06 0 1.33700000000001e-06 0 1.33705000000001e-06 0 1.33800000000001e-06 0 1.33805000000001e-06 0 1.33900000000001e-06 0 1.33905000000001e-06 0 1.34300000000001e-06 0 1.34305000000001e-06 0 1.34400000000001e-06 0 1.34405000000001e-06 0 1.34500000000001e-06 0 1.34510000000001e-06 1 1.34900000000001e-06 1 1.34905000000001e-06 0 1.35000000000001e-06 0 1.35005000000001e-06 0 1.35100000000001e-06 0 1.35110000000001e-06 1 1.35500000000001e-06 1 1.35505000000001e-06 0 1.35600000000001e-06 0 1.35605000000001e-06 0 1.35700000000001e-06 0 1.35710000000001e-06 1 1.36100000000001e-06 1 1.36105000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36300000000001e-06 0 1.36310000000001e-06 1 1.36700000000001e-06 1 1.36705000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.36900000000001e-06 0 1.36910000000001e-06 1 1.37300000000001e-06 1 1.37305000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37500000000001e-06 0 1.37510000000001e-06 1 1.37900000000001e-06 1 1.37905000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38100000000001e-06 0 1.38110000000001e-06 1 1.38500000000001e-06 1 1.38505000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.38700000000001e-06 0 1.38710000000001e-06 1 1.39100000000001e-06 1 1.39105000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39300000000001e-06 0 1.39310000000001e-06 1 1.39700000000001e-06 1 1.39705000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.39900000000001e-06 0 1.39910000000001e-06 1 1.40300000000001e-06 1 1.40305000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40500000000001e-06 0 1.40510000000001e-06 1 1.40900000000001e-06 1 1.40905000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41100000000001e-06 0 1.41110000000001e-06 1 1.41500000000001e-06 1 1.41505000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.41700000000001e-06 0 1.41710000000001e-06 1 1.42100000000001e-06 1 1.42105000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42300000000001e-06 0 1.42310000000001e-06 1 1.42700000000001e-06 1 1.42705000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.42900000000001e-06 0 1.42910000000001e-06 1 1.43300000000001e-06 1 1.43305000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43500000000001e-06 0 1.43510000000001e-06 1 1.43900000000001e-06 1 1.43905000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44100000000001e-06 0 1.44110000000001e-06 1 1.44500000000001e-06 1 1.44505000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.44700000000001e-06 0 1.44710000000001e-06 1 1.45100000000001e-06 1 1.45105000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45300000000001e-06 0 1.45310000000001e-06 1 1.45700000000001e-06 1 1.45705000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.45900000000001e-06 0 1.45910000000001e-06 1 1.46300000000002e-06 1 1.46305000000001e-06 0 1.46400000000002e-06 0 1.46405000000002e-06 0 1.46500000000002e-06 0 1.46510000000002e-06 1 1.46900000000002e-06 1 1.46905000000002e-06 0 1.47000000000002e-06 0 1.47005000000002e-06 0 1.47100000000002e-06 0 1.47110000000002e-06 1 1.47500000000002e-06 1 1.47505000000002e-06 0 1.47600000000002e-06 0 1.47605000000002e-06 0 1.47700000000002e-06 0 1.47710000000002e-06 1 1.48100000000002e-06 1 1.48105000000002e-06 0 1.48200000000002e-06 0 1.48205000000002e-06 0 1.48300000000002e-06 0 1.48310000000002e-06 1 1.48700000000002e-06 1 1.48705000000002e-06 0 1.48800000000002e-06 0 1.48805000000002e-06 0 1.48900000000002e-06 0 1.48910000000002e-06 1 1.49300000000002e-06 1 1.49305000000002e-06 0 1.49400000000002e-06 0 1.49405000000002e-06 0 1.49500000000002e-06 0 1.49510000000002e-06 1 1.49900000000002e-06 1 1.49905000000002e-06 0 1.50000000000002e-06 0 1.50005000000002e-06 0 1.50100000000002e-06 0 1.50110000000002e-06 1 1.50500000000002e-06 1 1.50505000000002e-06 0 1.50600000000002e-06 0 1.50605000000002e-06 0 1.50700000000002e-06 0 1.50710000000002e-06 1 1.51100000000002e-06 1 1.51105000000002e-06 0 1.51200000000002e-06 0 1.51205000000002e-06 0 1.51300000000002e-06 0 1.51310000000002e-06 1 1.51700000000002e-06 1 1.51705000000002e-06 0 1.51800000000002e-06 0 1.51805000000002e-06 0 1.51900000000002e-06 0 1.51910000000002e-06 1 1.52300000000002e-06 1 1.52305000000002e-06 0 1.52400000000002e-06 0 1.52405000000002e-06 0 1.52500000000002e-06 0 1.52510000000002e-06 1 1.52900000000002e-06 1 1.52905000000002e-06 0 1.53000000000002e-06 0 1.53005000000002e-06 0 1.53100000000002e-06 0 1.53110000000002e-06 1 1.53500000000002e-06 1 1.53505000000002e-06 0 1.53600000000002e-06 0 1.53605000000002e-06 0 1.53700000000002e-06 0 1.53705000000002e-06 0 1.54100000000002e-06 0 1.54105000000002e-06 0 1.54200000000002e-06 0 1.54205000000002e-06 0 1.54300000000002e-06 0 1.54305000000002e-06 0 1.54700000000002e-06 0 1.54705000000002e-06 0 1.54800000000002e-06 0 1.54805000000002e-06 0 1.54900000000002e-06 0 1.54905000000002e-06 0 1.55300000000002e-06 0 1.55305000000002e-06 0 1.55400000000002e-06 0 1.55405000000002e-06 0 1.55500000000002e-06 0 1.55505000000002e-06 0 1.55900000000002e-06 0 1.55905000000002e-06 0 1.56000000000002e-06 0 1.56005000000002e-06 0 1.56100000000002e-06 0 1.56105000000002e-06 0 1.56500000000002e-06 0 1.56505000000002e-06 0 1.56600000000002e-06 0 1.56605000000002e-06 0 1.56700000000002e-06 0 1.56705000000002e-06 0 1.57100000000002e-06 0 1.57105000000002e-06 0 1.57200000000002e-06 0 1.57205000000002e-06 0 1.57300000000002e-06 0 1.57305000000002e-06 0 1.57700000000002e-06 0 1.57705000000002e-06 0 1.57800000000002e-06 0 1.57805000000002e-06 0 1.57900000000002e-06 0 1.57905000000002e-06 0 1.58300000000002e-06 0 1.58305000000002e-06 0 1.58400000000002e-06 0 1.58405000000002e-06 0 1.58500000000002e-06 0 1.58505000000002e-06 0 1.58900000000002e-06 0 1.58905000000002e-06 0 1.59000000000002e-06 0 1.59005000000002e-06 0 1.59100000000002e-06 0 1.59105000000002e-06 0 1.59500000000002e-06 0 1.59505000000002e-06 0 1.59600000000002e-06 0 1.59605000000002e-06 0 1.59700000000002e-06 0 1.59705000000002e-06 0 1.60100000000002e-06 0 1.60105000000002e-06 0 1.60200000000002e-06 0 1.60205000000002e-06 0 1.60300000000002e-06 0 1.60305000000002e-06 0 1.60700000000002e-06 0 1.60705000000002e-06 0 1.60800000000002e-06 0 1.60805000000002e-06 0 1.60900000000002e-06 0 1.60905000000002e-06 0 1.61300000000002e-06 0 1.61305000000002e-06 0 1.61400000000002e-06 0 1.61405000000002e-06 0 1.61500000000002e-06 0 1.61505000000002e-06 0 1.61900000000002e-06 0 1.61905000000002e-06 0 1.62000000000002e-06 0 1.62005000000002e-06 0 1.62100000000002e-06 0 1.62105000000002e-06 0 1.62500000000002e-06 0 1.62505000000002e-06 0 1.62600000000002e-06 0 1.62605000000002e-06 0 1.62700000000002e-06 0 1.62705000000002e-06 0 1.63100000000002e-06 0 1.63105000000002e-06 0 1.63200000000002e-06 0 1.63205000000002e-06 0 1.63300000000002e-06 0 1.63305000000002e-06 0 1.63700000000002e-06 0 1.63705000000002e-06 0 1.63800000000002e-06 0 1.63805000000002e-06 0 1.63900000000002e-06 0 1.63905000000002e-06 0 1.64300000000002e-06 0 1.64305000000002e-06 0 1.64400000000002e-06 0 1.64405000000002e-06 0 1.64500000000002e-06 0 1.64505000000002e-06 0 1.64900000000002e-06 0 1.64905000000002e-06 0 1.65000000000002e-06 0 1.65005000000002e-06 0 1.65100000000002e-06 0 1.65105000000002e-06 0 1.65500000000002e-06 0 1.65505000000002e-06 0 1.65600000000002e-06 0 1.65605000000002e-06 0 1.65700000000002e-06 0 1.65705000000002e-06 0 1.66100000000002e-06 0 1.66105000000002e-06 0 1.66200000000002e-06 0 1.66205000000002e-06 0 1.66300000000002e-06 0 1.66305000000002e-06 0 1.66700000000002e-06 0 1.66705000000002e-06 0 1.66800000000002e-06 0 1.66805000000002e-06 0 1.66900000000002e-06 0 1.66905000000002e-06 0 1.67300000000002e-06 0 1.67305000000002e-06 0 1.67400000000002e-06 0 1.67405000000002e-06 0 1.67500000000002e-06 0 1.67505000000002e-06 0 1.67900000000002e-06 0 1.67905000000002e-06 0 1.68000000000002e-06 0 1.68005000000002e-06 0 1.68100000000002e-06 0 1.68105000000002e-06 0 1.68500000000002e-06 0 1.68505000000002e-06 0 1.68600000000002e-06 0 1.68605000000002e-06 0 1.68700000000002e-06 0 1.68705000000002e-06 0 1.69100000000002e-06 0 1.69105000000002e-06 0 1.69200000000002e-06 0 1.69205000000002e-06 0 1.69300000000002e-06 0 1.69305000000002e-06 0 1.69700000000002e-06 0 1.69705000000002e-06 0 1.69800000000002e-06 0 1.69805000000002e-06 0 1.69900000000002e-06 0 1.69905000000002e-06 0 1.70300000000002e-06 0 1.70305000000002e-06 0 1.70400000000002e-06 0 1.70405000000002e-06 0 1.70500000000002e-06 0 1.70505000000002e-06 0 1.70900000000002e-06 0 1.70905000000002e-06 0 1.71000000000002e-06 0 1.71005000000002e-06 0 1.71100000000002e-06 0 1.71105000000002e-06 0 1.71500000000003e-06 0 1.71505000000002e-06 0 1.71600000000003e-06 0 1.71605000000003e-06 0 1.71700000000003e-06 0 1.71705000000003e-06 0 1.72100000000003e-06 0 1.72105000000003e-06 0 1.72200000000003e-06 0 1.72205000000003e-06 0 1.72300000000003e-06 0 1.72305000000003e-06 0 1.72700000000003e-06 0 1.72705000000003e-06 0 1.72800000000003e-06 0 1.72805000000003e-06 0 1.72900000000003e-06 0 1.72910000000003e-06 1 1.73300000000003e-06 1 1.73305000000003e-06 0 1.73400000000003e-06 0 1.73405000000003e-06 0 1.73500000000003e-06 0 1.73510000000003e-06 1 1.73900000000003e-06 1 1.73905000000003e-06 0 1.74000000000003e-06 0 1.74005000000003e-06 0 1.74100000000003e-06 0 1.74110000000003e-06 1 1.74500000000003e-06 1 1.74505000000003e-06 0 1.74600000000003e-06 0 1.74605000000003e-06 0 1.74700000000003e-06 0 1.74710000000003e-06 1 1.75100000000003e-06 1 1.75105000000003e-06 0 1.75200000000003e-06 0 1.75205000000003e-06 0 1.75300000000003e-06 0 1.75310000000003e-06 1 1.75700000000003e-06 1 1.75705000000003e-06 0 1.75800000000003e-06 0 1.75805000000003e-06 0 1.75900000000003e-06 0 1.75910000000003e-06 1 1.76300000000003e-06 1 1.76305000000003e-06 0 1.76400000000003e-06 0 1.76405000000003e-06 0 1.76500000000003e-06 0 1.76510000000003e-06 1 1.76900000000003e-06 1 1.76905000000003e-06 0 1.77000000000003e-06 0 1.77005000000003e-06 0 1.77100000000003e-06 0 1.77110000000003e-06 1 1.77500000000003e-06 1 1.77505000000003e-06 0 1.77600000000003e-06 0 1.77605000000003e-06 0 1.77700000000003e-06 0 1.77710000000003e-06 1 1.78100000000003e-06 1 1.78105000000003e-06 0 1.78200000000003e-06 0 1.78205000000003e-06 0 1.78300000000003e-06 0 1.78310000000003e-06 1 1.78700000000003e-06 1 1.78705000000003e-06 0 1.78800000000003e-06 0 1.78805000000003e-06 0 1.78900000000003e-06 0 1.78910000000003e-06 1 1.79300000000003e-06 1 1.79305000000003e-06 0 1.79400000000003e-06 0 1.79405000000003e-06 0 1.79500000000003e-06 0 1.79510000000003e-06 1 1.79900000000003e-06 1 1.79905000000003e-06 0 1.80000000000003e-06 0 1.80005000000003e-06 0 1.80100000000003e-06 0 1.80110000000003e-06 1 1.80500000000003e-06 1 1.80505000000003e-06 0 1.80600000000003e-06 0 1.80605000000003e-06 0 1.80700000000003e-06 0 1.80710000000003e-06 1 1.81100000000003e-06 1 1.81105000000003e-06 0 1.81200000000003e-06 0 1.81205000000003e-06 0 1.81300000000003e-06 0 1.81310000000003e-06 1 1.81700000000003e-06 1 1.81705000000003e-06 0 1.81800000000003e-06 0 1.81805000000003e-06 0 1.81900000000003e-06 0 1.81910000000003e-06 1 1.82300000000003e-06 1 1.82305000000003e-06 0 1.82400000000003e-06 0 1.82405000000003e-06 0 1.82500000000003e-06 0 1.82510000000003e-06 1 1.82900000000003e-06 1 1.82905000000003e-06 0 1.83000000000003e-06 0 1.83005000000003e-06 0 1.83100000000003e-06 0 1.83110000000003e-06 1 1.83500000000003e-06 1 1.83505000000003e-06 0 1.83600000000003e-06 0 1.83605000000003e-06 0 1.83700000000003e-06 0 1.83710000000003e-06 1 1.84100000000003e-06 1 1.84105000000003e-06 0 1.84200000000003e-06 0 1.84205000000003e-06 0 1.84300000000003e-06 0 1.84310000000003e-06 1 1.84700000000003e-06 1 1.84705000000003e-06 0 1.84800000000003e-06 0 1.84805000000003e-06 0 1.84900000000003e-06 0 1.84910000000003e-06 1 1.85300000000003e-06 1 1.85305000000003e-06 0 1.85400000000003e-06 0 1.85405000000003e-06 0 1.85500000000003e-06 0 1.85510000000003e-06 1 1.85900000000003e-06 1 1.85905000000003e-06 0 1.86000000000003e-06 0 1.86005000000003e-06 0 1.86100000000003e-06 0 1.86110000000003e-06 1 1.86500000000003e-06 1 1.86505000000003e-06 0 1.86600000000003e-06 0 1.86605000000003e-06 0 1.86700000000003e-06 0 1.86710000000003e-06 1 1.87100000000003e-06 1 1.87105000000003e-06 0 1.87200000000003e-06 0 1.87205000000003e-06 0 1.87300000000003e-06 0 1.87310000000003e-06 1 1.87700000000003e-06 1 1.87705000000003e-06 0 1.87800000000003e-06 0 1.87805000000003e-06 0 1.87900000000003e-06 0 1.87910000000003e-06 1 1.88300000000003e-06 1 1.88305000000003e-06 0 1.88400000000003e-06 0 1.88405000000003e-06 0 1.88500000000003e-06 0 1.88510000000003e-06 1 1.88900000000003e-06 1 1.88905000000003e-06 0 1.89000000000003e-06 0 1.89005000000003e-06 0 1.89100000000003e-06 0 1.89110000000003e-06 1 1.89500000000003e-06 1 1.89505000000003e-06 0 1.89600000000003e-06 0 1.89605000000003e-06 0 1.89700000000003e-06 0 1.89710000000003e-06 1 1.90100000000003e-06 1 1.90105000000003e-06 0 1.90200000000003e-06 0 1.90205000000003e-06 0 1.90300000000003e-06 0 1.90310000000003e-06 1 1.90700000000003e-06 1 1.90705000000003e-06 0 1.90800000000003e-06 0 1.90805000000003e-06 0 1.90900000000003e-06 0 1.90910000000003e-06 1 1.91300000000003e-06 1 1.91305000000003e-06 0 1.91400000000003e-06 0 1.91405000000003e-06 0 1.91500000000003e-06 0 1.91510000000003e-06 1 1.91900000000003e-06 1 1.91905000000003e-06 0 1.92000000000003e-06 0 1.92005000000003e-06 0 1.92100000000003e-06 0 1.92105000000003e-06 0 1.92500000000003e-06 0 1.92505000000003e-06 0 1.92600000000003e-06 0 1.92605000000003e-06 0 1.92700000000003e-06 0 1.92705000000003e-06 0 1.93100000000003e-06 0 1.93105000000003e-06 0 1.93200000000003e-06 0 1.93205000000003e-06 0 1.93300000000003e-06 0 1.93305000000003e-06 0 1.93700000000003e-06 0 1.93705000000003e-06 0 1.93800000000003e-06 0 1.93805000000003e-06 0 1.93900000000003e-06 0 1.93905000000003e-06 0 1.94300000000003e-06 0 1.94305000000003e-06 0 1.94400000000003e-06 0 1.94405000000003e-06 0 1.94500000000003e-06 0 1.94505000000003e-06 0 1.94900000000003e-06 0 1.94905000000003e-06 0 1.95000000000003e-06 0 1.95005000000003e-06 0 1.95100000000003e-06 0 1.95105000000003e-06 0 1.95500000000003e-06 0 1.95505000000003e-06 0 1.95600000000003e-06 0 1.95605000000003e-06 0 1.95700000000003e-06 0 1.95705000000003e-06 0 1.96100000000003e-06 0 1.96105000000003e-06 0 1.96200000000003e-06 0 1.96205000000003e-06 0 1.96300000000003e-06 0 1.96305000000003e-06 0 1.96700000000003e-06 0 1.96705000000003e-06 0 1.96800000000003e-06 0 1.96805000000003e-06 0 1.96900000000003e-06 0 1.96905000000003e-06 0 1.97300000000003e-06 0 1.97305000000003e-06 0 1.97400000000003e-06 0 1.97405000000003e-06 0 1.97500000000003e-06 0 1.97505000000003e-06 0 1.97900000000003e-06 0 1.97905000000003e-06 0 1.98000000000003e-06 0 1.98005000000003e-06 0 1.98100000000003e-06 0 1.98105000000003e-06 0 1.98500000000003e-06 0 1.98505000000003e-06 0 1.98600000000003e-06 0 1.98605000000003e-06 0 1.98700000000003e-06 0 1.98705000000003e-06 0 1.99100000000003e-06 0 1.99105000000003e-06 0 1.99200000000003e-06 0 1.99205000000003e-06 0 1.99300000000003e-06 0 1.99305000000003e-06 0 1.99700000000003e-06 0 1.99705000000003e-06 0 1.99800000000003e-06 0 1.99805000000003e-06 0 1.99900000000003e-06 0 1.99905000000003e-06 0 2.00300000000003e-06 0 2.00305000000003e-06 0 2.00400000000003e-06 0 2.00405000000003e-06 0 2.00500000000003e-06 0 2.00505000000003e-06 0 2.00900000000003e-06 0 2.00905000000003e-06 0 2.01000000000003e-06 0 2.01005000000003e-06 0 2.01100000000003e-06 0 2.01105000000003e-06 0 2.01500000000003e-06 0 2.01505000000003e-06 0 2.01600000000003e-06 0 2.01605000000003e-06 0 2.01700000000003e-06 0 2.01705000000003e-06 0 2.02100000000003e-06 0 2.02105000000003e-06 0 2.02200000000003e-06 0 2.02205000000003e-06 0 2.02300000000003e-06 0 2.02305000000003e-06 0 2.02700000000003e-06 0 2.02705000000003e-06 0 2.02800000000003e-06 0 2.02805000000003e-06 0 2.02900000000003e-06 0 2.02905000000003e-06 0 2.03300000000003e-06 0 2.03305000000003e-06 0 2.03400000000003e-06 0 2.03405000000003e-06 0 2.03500000000003e-06 0 2.03505000000003e-06 0 2.03900000000003e-06 0 2.03905000000003e-06 0 2.04000000000003e-06 0 2.04005000000003e-06 0 2.04100000000003e-06 0 2.04105000000003e-06 0 2.04500000000003e-06 0 2.04505000000003e-06 0 2.04600000000003e-06 0 2.04605000000003e-06 0 2.04700000000003e-06 0 2.04705000000003e-06 0 2.05100000000003e-06 0 2.05105000000003e-06 0 2.05200000000003e-06 0 2.05205000000003e-06 0 2.05300000000003e-06 0 2.05305000000003e-06 0 2.05700000000003e-06 0 2.05705000000003e-06 0 2.05800000000003e-06 0 2.05805000000003e-06 0 2.05900000000003e-06 0 2.05905000000003e-06 0 2.06300000000003e-06 0 2.06305000000003e-06 0 2.06400000000003e-06 0 2.06405000000003e-06 0 2.06500000000003e-06 0 2.06505000000003e-06 0 2.06900000000003e-06 0 2.06905000000003e-06 0 2.07000000000003e-06 0 2.07005000000003e-06 0 2.07100000000003e-06 0 2.07105000000003e-06 0 2.07500000000003e-06 0 2.07505000000003e-06 0 2.07600000000003e-06 0 2.07605000000003e-06 0 2.07700000000003e-06 0 2.07705000000003e-06 0 2.08100000000003e-06 0 2.08105000000003e-06 0 2.08200000000003e-06 0 2.08205000000003e-06 0 2.08300000000003e-06 0 2.08305000000003e-06 0 2.08700000000003e-06 0 2.08705000000003e-06 0 2.08800000000003e-06 0 2.08805000000003e-06 0 2.08900000000003e-06 0 2.08905000000003e-06 0 2.09300000000003e-06 0 2.09305000000003e-06 0 2.09400000000003e-06 0 2.09405000000003e-06 0 2.09500000000003e-06 0 2.09505000000003e-06 0 2.09900000000003e-06 0 2.09905000000003e-06 0 2.10000000000003e-06 0 2.10005000000003e-06 0 2.10100000000003e-06 0 2.10105000000003e-06 0 2.10500000000003e-06 0 2.10505000000003e-06 0 2.10600000000003e-06 0 2.10605000000003e-06 0 2.10700000000003e-06 0 2.10705000000003e-06 0 2.11100000000003e-06 0 2.11105000000003e-06 0 2.11200000000003e-06 0 2.11205000000003e-06 0 2.11300000000003e-06 0 2.11310000000003e-06 1 2.11700000000003e-06 1 2.11705000000003e-06 0 2.11800000000003e-06 0 2.11805000000003e-06 0 2.11900000000003e-06 0 2.11910000000003e-06 1 2.12300000000003e-06 1 2.12305000000003e-06 0 2.12400000000003e-06 0 2.12405000000003e-06 0 2.12500000000003e-06 0 2.12510000000003e-06 1 2.12900000000003e-06 1 2.12905000000003e-06 0 2.13000000000003e-06 0 2.13005000000003e-06 0 2.13100000000003e-06 0 2.13110000000003e-06 1 2.13500000000003e-06 1 2.13505000000003e-06 0 2.13600000000003e-06 0 2.13605000000003e-06 0 2.13700000000003e-06 0 2.13710000000003e-06 1 2.14100000000003e-06 1 2.14105000000003e-06 0 2.14200000000003e-06 0 2.14205000000003e-06 0 2.14300000000003e-06 0 2.14310000000003e-06 1 2.14700000000003e-06 1 2.14705000000003e-06 0 2.14800000000003e-06 0 2.14805000000003e-06 0 2.14900000000003e-06 0 2.14910000000003e-06 1 2.15300000000003e-06 1 2.15305000000003e-06 0 2.15400000000003e-06 0 2.15405000000003e-06 0 2.15500000000003e-06 0 2.15510000000003e-06 1 2.15900000000003e-06 1 2.15905000000003e-06 0 2.16000000000003e-06 0 2.16005000000003e-06 0 2.16100000000003e-06 0 2.16110000000003e-06 1 2.16500000000003e-06 1 2.16505000000003e-06 0 2.16600000000003e-06 0 2.16605000000003e-06 0 2.16700000000003e-06 0 2.16710000000003e-06 1 2.17100000000003e-06 1 2.17105000000003e-06 0 2.17200000000003e-06 0 2.17205000000003e-06 0 2.17300000000003e-06 0 2.17310000000003e-06 1 2.17700000000003e-06 1 2.17705000000003e-06 0 2.17800000000003e-06 0 2.17805000000003e-06 0 2.17900000000003e-06 0 2.17910000000003e-06 1 2.18300000000003e-06 1 2.18305000000003e-06 0 2.18400000000003e-06 0 2.18405000000003e-06 0 2.18500000000003e-06 0 2.18510000000003e-06 1 2.18900000000003e-06 1 2.18905000000003e-06 0 2.19000000000003e-06 0 2.19005000000003e-06 0 2.19100000000003e-06 0 2.19110000000003e-06 1 2.19500000000003e-06 1 2.19505000000003e-06 0 2.19600000000003e-06 0 2.19605000000003e-06 0 2.19700000000003e-06 0 2.19710000000003e-06 1 2.20100000000003e-06 1 2.20105000000003e-06 0 2.20200000000003e-06 0 2.20205000000003e-06 0 2.20300000000003e-06 0 2.20310000000003e-06 1 2.20700000000003e-06 1 2.20705000000003e-06 0 2.20800000000003e-06 0 2.20805000000003e-06 0 2.20900000000003e-06 0 2.20910000000003e-06 1 2.21300000000003e-06 1 2.21305000000003e-06 0 2.21400000000003e-06 0 2.21405000000003e-06 0 2.21500000000003e-06 0 2.21510000000003e-06 1 2.21900000000003e-06 1 2.21905000000003e-06 0 2.22000000000003e-06 0 2.22005000000003e-06 0 2.22100000000003e-06 0 2.22110000000003e-06 1 2.22500000000003e-06 1 2.22505000000003e-06 0 2.22600000000003e-06 0 2.22605000000003e-06 0 2.22700000000003e-06 0 2.22710000000003e-06 1 2.23100000000003e-06 1 2.23105000000003e-06 0 2.23200000000003e-06 0 2.23205000000003e-06 0 2.23300000000003e-06 0 2.23310000000003e-06 1 2.23700000000003e-06 1 2.23705000000003e-06 0 2.23800000000003e-06 0 2.23805000000003e-06 0 2.23900000000003e-06 0 2.23910000000003e-06 1 2.24300000000003e-06 1 2.24305000000003e-06 0 2.24400000000003e-06 0 2.24405000000003e-06 0 2.24500000000003e-06 0 2.24510000000003e-06 1 2.24900000000003e-06 1 2.24905000000003e-06 0 2.25000000000003e-06 0 2.25005000000003e-06 0 2.25100000000003e-06 0 2.25110000000003e-06 1 2.25500000000003e-06 1 2.25505000000003e-06 0 2.25600000000003e-06 0 2.25605000000003e-06 0 2.25700000000003e-06 0 2.25710000000003e-06 1 2.26100000000003e-06 1 2.26105000000003e-06 0 2.26200000000003e-06 0 2.26205000000003e-06 0 2.26300000000003e-06 0 2.26310000000003e-06 1 2.26700000000003e-06 1 2.26705000000003e-06 0 2.26800000000003e-06 0 2.26805000000003e-06 0 2.26900000000003e-06 0 2.26910000000003e-06 1 2.27300000000003e-06 1 2.27305000000003e-06 0 2.27400000000003e-06 0 2.27405000000003e-06 0 2.27500000000003e-06 0 2.27510000000003e-06 1 2.27900000000003e-06 1 2.27905000000003e-06 0 2.28000000000003e-06 0 2.28005000000003e-06 0 2.28100000000003e-06 0 2.28110000000003e-06 1 2.28500000000003e-06 1 2.28505000000003e-06 0 2.28600000000003e-06 0 2.28605000000003e-06 0 2.28700000000003e-06 0 2.28710000000003e-06 1 2.29100000000003e-06 1 2.29105000000003e-06 0 2.29200000000003e-06 0 2.29205000000003e-06 0 2.29300000000003e-06 0 2.29310000000003e-06 1 2.29700000000003e-06 1 2.29705000000003e-06 0 2.29800000000003e-06 0 2.29805000000003e-06 0 2.29900000000003e-06 0 2.29910000000003e-06 1 2.30300000000003e-06 1 2.30305000000003e-06 0 2.30400000000003e-06 0 2.30405000000003e-06 0 2.30500000000003e-06 0 2.30505000000003e-06 0 2.30900000000003e-06 0 2.30905000000003e-06 0 2.31000000000003e-06 0 2.31005000000003e-06 0 2.31100000000003e-06 0 2.31105000000003e-06 0 2.31500000000003e-06 0 2.31505000000003e-06 0 2.31600000000003e-06 0 2.31605000000003e-06 0 2.31700000000003e-06 0 2.31705000000003e-06 0 2.32100000000003e-06 0 2.32105000000003e-06 0 2.32200000000003e-06 0 2.32205000000003e-06 0 2.32300000000003e-06 0 2.32305000000003e-06 0 2.32700000000003e-06 0 2.32705000000003e-06 0 2.32800000000003e-06 0 2.32805000000003e-06 0 2.32900000000003e-06 0 2.32905000000003e-06 0 2.33300000000003e-06 0 2.33305000000003e-06 0 2.33400000000003e-06 0 2.33405000000003e-06 0 2.33500000000003e-06 0 2.33505000000003e-06 0 2.33900000000003e-06 0 2.33905000000003e-06 0 2.34000000000003e-06 0 2.34005000000003e-06 0 2.34100000000003e-06 0 2.34105000000003e-06 0 2.34500000000003e-06 0 2.34505000000003e-06 0 2.34600000000003e-06 0 2.34605000000003e-06 0 2.34700000000003e-06 0 2.34705000000003e-06 0 2.35100000000003e-06 0 2.35105000000003e-06 0 2.35200000000003e-06 0 2.35205000000003e-06 0 2.35300000000003e-06 0 2.35305000000004e-06 0 2.35700000000003e-06 0 2.35705000000003e-06 0 2.35800000000003e-06 0 2.35805000000003e-06 0 2.35900000000003e-06 0 2.35905000000004e-06 0 2.36300000000003e-06 0 2.36305000000003e-06 0 2.36400000000003e-06 0 2.36405000000003e-06 0 2.36500000000003e-06 0 2.36505000000004e-06 0 2.36900000000003e-06 0 2.36905000000003e-06 0 2.37000000000003e-06 0 2.37005000000004e-06 0 2.37100000000003e-06 0 2.37105000000004e-06 0 2.37500000000003e-06 0 2.37505000000003e-06 0 2.37600000000003e-06 0 2.37605000000004e-06 0 2.37700000000004e-06 0 2.37705000000004e-06 0 2.38100000000003e-06 0 2.38105000000003e-06 0 2.38200000000003e-06 0 2.38205000000004e-06 0 2.38300000000004e-06 0 2.38305000000004e-06 0 2.38700000000003e-06 0 2.38705000000004e-06 0 2.38800000000003e-06 0 2.38805000000004e-06 0 2.38900000000004e-06 0 2.38905000000004e-06 0 2.39300000000003e-06 0 2.39305000000004e-06 0 2.39400000000004e-06 0 2.39405000000004e-06 0 2.39500000000004e-06 0 2.39505000000004e-06 0 2.39900000000003e-06 0 2.39905000000004e-06 0 2.40000000000004e-06 0 2.40005000000004e-06 0 2.40100000000004e-06 0 2.40105000000004e-06 0 2.40500000000003e-06 0 2.40505000000004e-06 0 2.40600000000004e-06 0 2.40605000000004e-06 0 2.40700000000004e-06 0 2.40705000000004e-06 0 2.41100000000004e-06 0 2.41105000000004e-06 0 2.41200000000004e-06 0 2.41205000000004e-06 0 2.41300000000004e-06 0 2.41305000000004e-06 0 2.41700000000004e-06 0 2.41705000000004e-06 0 2.41800000000004e-06 0 2.41805000000004e-06 0 2.41900000000004e-06 0 2.41905000000004e-06 0 2.42300000000004e-06 0 2.42305000000004e-06 0 2.42400000000004e-06 0 2.42405000000004e-06 0 2.42500000000004e-06 0 2.42505000000004e-06 0 2.42900000000004e-06 0 2.42905000000004e-06 0 2.43000000000004e-06 0 2.43005000000004e-06 0 2.43100000000004e-06 0 2.43105000000004e-06 0 2.43500000000004e-06 0 2.43505000000004e-06 0 2.43600000000004e-06 0 2.43605000000004e-06 0 2.43700000000004e-06 0 2.43705000000004e-06 0 2.44100000000004e-06 0 2.44105000000004e-06 0 2.44200000000004e-06 0 2.44205000000004e-06 0 2.44300000000004e-06 0 2.44305000000004e-06 0 2.44700000000004e-06 0 2.44705000000004e-06 0 2.44800000000004e-06 0 2.44805000000004e-06 0 2.44900000000004e-06 0 2.44905000000004e-06 0 2.45300000000004e-06 0 2.45305000000004e-06 0 2.45400000000004e-06 0 2.45405000000004e-06 0 2.45500000000004e-06 0 2.45505000000004e-06 0 2.45900000000004e-06 0 2.45905000000004e-06 0 2.46000000000004e-06 0 2.46005000000004e-06 0 2.46100000000004e-06 0 2.46105000000004e-06 0 2.46500000000004e-06 0 2.46505000000004e-06 0 2.46600000000004e-06 0 2.46605000000004e-06 0 2.46700000000004e-06 0 2.46705000000004e-06 0 2.47100000000004e-06 0 2.47105000000004e-06 0 2.47200000000004e-06 0 2.47205000000004e-06 0 2.47300000000004e-06 0 2.47305000000004e-06 0 2.47700000000004e-06 0 2.47705000000004e-06 0 2.47800000000004e-06 0 2.47805000000004e-06 0 2.47900000000004e-06 0 2.47905000000004e-06 0 2.48300000000004e-06 0 2.48305000000004e-06 0 2.48400000000004e-06 0 2.48405000000004e-06 0 2.48500000000004e-06 0 2.48505000000004e-06 0 2.48900000000004e-06 0 2.48905000000004e-06 0 2.49000000000004e-06 0 2.49005000000004e-06 0 2.49100000000004e-06 0 2.49105000000004e-06 0 2.49500000000004e-06 0 2.49505000000004e-06 0 2.49600000000004e-06 0 2.49605000000004e-06 0 2.49700000000004e-06 0 2.49710000000004e-06 1 2.50100000000004e-06 1 2.50105000000004e-06 0 2.50200000000004e-06 0 2.50205000000004e-06 0 2.50300000000004e-06 0 2.50310000000004e-06 1 2.50700000000004e-06 1 2.50705000000004e-06 0 2.50800000000004e-06 0 2.50805000000004e-06 0 2.50900000000004e-06 0 2.50910000000004e-06 1 2.51300000000004e-06 1 2.51305000000004e-06 0 2.51400000000004e-06 0 2.51405000000004e-06 0 2.51500000000004e-06 0 2.51510000000004e-06 1 2.51900000000004e-06 1 2.51905000000004e-06 0 2.52000000000004e-06 0 2.52005000000004e-06 0 2.52100000000004e-06 0 2.52110000000004e-06 1 2.52500000000004e-06 1 2.52505000000004e-06 0 2.52600000000004e-06 0 2.52605000000004e-06 0 2.52700000000004e-06 0 2.52710000000004e-06 1 2.53100000000004e-06 1 2.53105000000004e-06 0 2.53200000000004e-06 0 2.53205000000004e-06 0 2.53300000000004e-06 0 2.53310000000004e-06 1 2.53700000000004e-06 1 2.53705000000004e-06 0 2.53800000000004e-06 0 2.53805000000004e-06 0 2.53900000000004e-06 0 2.53910000000004e-06 1 2.54300000000004e-06 1 2.54305000000004e-06 0 2.54400000000004e-06 0 2.54405000000004e-06 0 2.54500000000004e-06 0 2.54510000000004e-06 1 2.54900000000004e-06 1 2.54905000000004e-06 0 2.55000000000004e-06 0 2.55005000000004e-06 0 2.55100000000004e-06 0 2.55110000000004e-06 1 2.55500000000004e-06 1 2.55505000000004e-06 0 2.55600000000004e-06 0 2.55605000000004e-06 0 2.55700000000004e-06 0 2.55710000000004e-06 1 2.56100000000004e-06 1 2.56105000000004e-06 0 2.56200000000004e-06 0 2.56205000000004e-06 0 2.56300000000004e-06 0 2.56310000000004e-06 1 2.56700000000004e-06 1 2.56705000000004e-06 0 2.56800000000004e-06 0 2.56805000000004e-06 0 2.56900000000004e-06 0 2.56910000000004e-06 1 2.57300000000004e-06 1 2.57305000000004e-06 0 2.57400000000004e-06 0 2.57405000000004e-06 0 2.57500000000004e-06 0 2.57510000000004e-06 1 2.57900000000004e-06 1 2.57905000000004e-06 0 2.58000000000004e-06 0 2.58005000000004e-06 0 2.58100000000004e-06 0 2.58110000000004e-06 1 2.58500000000004e-06 1 2.58505000000004e-06 0 2.58600000000004e-06 0 2.58605000000004e-06 0 2.58700000000004e-06 0 2.58710000000004e-06 1 2.59100000000004e-06 1 2.59105000000004e-06 0 2.59200000000004e-06 0 2.59205000000004e-06 0 2.59300000000004e-06 0 2.59310000000004e-06 1 2.59700000000004e-06 1 2.59705000000004e-06 0 2.59800000000004e-06 0 2.59805000000004e-06 0 2.59900000000004e-06 0 2.59910000000004e-06 1 2.60300000000004e-06 1 2.60305000000004e-06 0 2.60400000000004e-06 0 2.60405000000004e-06 0 2.60500000000004e-06 0 2.60510000000004e-06 1 2.60900000000004e-06 1 2.60905000000004e-06 0 2.61000000000004e-06 0 2.61005000000004e-06 0 2.61100000000004e-06 0 2.61110000000004e-06 1 2.61500000000004e-06 1 2.61505000000004e-06 0 2.61600000000004e-06 0 2.61605000000004e-06 0 2.61700000000004e-06 0 2.61710000000004e-06 1 2.62100000000004e-06 1 2.62105000000004e-06 0 2.62200000000004e-06 0 2.62205000000004e-06 0 2.62300000000004e-06 0 2.62310000000004e-06 1 2.62700000000004e-06 1 2.62705000000004e-06 0 2.62800000000004e-06 0 2.62805000000004e-06 0 2.62900000000004e-06 0 2.62910000000004e-06 1 2.63300000000004e-06 1 2.63305000000004e-06 0 2.63400000000004e-06 0 2.63405000000004e-06 0 2.63500000000004e-06 0 2.63510000000004e-06 1 2.63900000000004e-06 1 2.63905000000004e-06 0 2.64000000000004e-06 0 2.64005000000004e-06 0 2.64100000000004e-06 0 2.64110000000004e-06 1 2.64500000000004e-06 1 2.64505000000004e-06 0 2.64600000000004e-06 0 2.64605000000004e-06 0 2.64700000000004e-06 0 2.64710000000004e-06 1 2.65100000000004e-06 1 2.65105000000004e-06 0 2.65200000000004e-06 0 2.65205000000004e-06 0 2.65300000000004e-06 0 2.65310000000004e-06 1 2.65700000000004e-06 1 2.65705000000004e-06 0 2.65800000000004e-06 0 2.65805000000004e-06 0 2.65900000000004e-06 0 2.65910000000004e-06 1 2.66300000000004e-06 1 2.66305000000004e-06 0 2.66400000000004e-06 0 2.66405000000004e-06 0 2.66500000000004e-06 0 2.66510000000004e-06 1 2.66900000000004e-06 1 2.66905000000004e-06 0 2.67000000000004e-06 0 2.67005000000004e-06 0 2.67100000000004e-06 0 2.67110000000004e-06 1 2.67500000000004e-06 1 2.67505000000004e-06 0 2.67600000000004e-06 0 2.67605000000004e-06 0 2.67700000000004e-06 0 2.67710000000004e-06 1 2.68100000000004e-06 1 2.68105000000004e-06 0 2.68200000000004e-06 0 2.68205000000004e-06 0 2.68300000000004e-06 0 2.68310000000004e-06 1 2.68700000000004e-06 1 2.68705000000004e-06 0 2.68800000000004e-06 0 2.68805000000004e-06 0 2.68900000000004e-06 0 2.68905000000004e-06 0 2.69300000000004e-06 0 2.69305000000004e-06 0 2.69400000000004e-06 0 2.69405000000004e-06 0 2.69500000000004e-06 0 2.69505000000004e-06 0 2.69900000000004e-06 0 2.69905000000004e-06 0 2.70000000000004e-06 0 2.70005000000004e-06 0 2.70100000000004e-06 0 2.70105000000004e-06 0 2.70500000000004e-06 0 2.70505000000004e-06 0 2.70600000000004e-06 0 2.70605000000004e-06 0 2.70700000000004e-06 0 2.70705000000004e-06 0 2.71100000000004e-06 0 2.71105000000004e-06 0 2.71200000000004e-06 0 2.71205000000004e-06 0 2.71300000000004e-06 0 2.71305000000004e-06 0 2.71700000000004e-06 0 2.71705000000004e-06 0 2.71800000000004e-06 0 2.71805000000004e-06 0 2.71900000000004e-06 0 2.71905000000004e-06 0 2.72300000000004e-06 0 2.72305000000004e-06 0 2.72400000000004e-06 0 2.72405000000004e-06 0 2.72500000000004e-06 0 2.72505000000004e-06 0 2.72900000000004e-06 0 2.72905000000004e-06 0 2.73000000000004e-06 0 2.73005000000004e-06 0 2.73100000000004e-06 0 2.73105000000004e-06 0 2.73500000000004e-06 0 2.73505000000004e-06 0 2.73600000000004e-06 0 2.73605000000004e-06 0 2.73700000000004e-06 0 2.73705000000004e-06 0 2.74100000000004e-06 0 2.74105000000004e-06 0 2.74200000000004e-06 0 2.74205000000004e-06 0 2.74300000000004e-06 0 2.74305000000004e-06 0 2.74700000000004e-06 0 2.74705000000004e-06 0 2.74800000000004e-06 0 2.74805000000004e-06 0 2.74900000000004e-06 0 2.74905000000004e-06 0 2.75300000000004e-06 0 2.75305000000004e-06 0 2.75400000000004e-06 0 2.75405000000004e-06 0 2.75500000000004e-06 0 2.75505000000004e-06 0 2.75900000000004e-06 0 2.75905000000004e-06 0 2.76000000000004e-06 0 2.76005000000004e-06 0 2.76100000000004e-06 0 2.76105000000004e-06 0 2.76500000000004e-06 0 2.76505000000004e-06 0 2.76600000000004e-06 0 2.76605000000004e-06 0 2.76700000000004e-06 0 2.76705000000004e-06 0 2.77100000000004e-06 0 2.77105000000004e-06 0 2.77200000000004e-06 0 2.77205000000004e-06 0 2.77300000000004e-06 0 2.77305000000004e-06 0 2.77700000000004e-06 0 2.77705000000004e-06 0 2.77800000000004e-06 0 2.77805000000004e-06 0 2.77900000000004e-06 0 2.77905000000004e-06 0 2.78300000000004e-06 0 2.78305000000004e-06 0 2.78400000000004e-06 0 2.78405000000004e-06 0 2.78500000000004e-06 0 2.78505000000004e-06 0 2.78900000000004e-06 0 2.78905000000004e-06 0 2.79000000000004e-06 0 2.79005000000004e-06 0 2.79100000000004e-06 0 2.79105000000004e-06 0 2.79500000000004e-06 0 2.79505000000004e-06 0 2.79600000000004e-06 0 2.79605000000004e-06 0 2.79700000000004e-06 0 2.79705000000004e-06 0 2.80100000000004e-06 0 2.80105000000004e-06 0 2.80200000000004e-06 0 2.80205000000004e-06 0 2.80300000000004e-06 0 2.80305000000004e-06 0 2.80700000000004e-06 0 2.80705000000004e-06 0 2.80800000000004e-06 0 2.80805000000004e-06 0 2.80900000000004e-06 0 2.80905000000004e-06 0 2.81300000000004e-06 0 2.81305000000004e-06 0 2.81400000000004e-06 0 2.81405000000004e-06 0 2.81500000000004e-06 0 2.81505000000004e-06 0 2.81900000000004e-06 0 2.81905000000004e-06 0 2.82000000000004e-06 0 2.82005000000004e-06 0 2.82100000000004e-06 0 2.82105000000004e-06 0 2.82500000000004e-06 0 2.82505000000004e-06 0 2.82600000000004e-06 0 2.82605000000004e-06 0 2.82700000000004e-06 0 2.82705000000004e-06 0 2.83100000000004e-06 0 2.83105000000004e-06 0 2.83200000000004e-06 0 2.83205000000004e-06 0 2.83300000000004e-06 0 2.83305000000004e-06 0 2.83700000000004e-06 0 2.83705000000004e-06 0 2.83800000000004e-06 0 2.83805000000004e-06 0 2.83900000000004e-06 0 2.83905000000004e-06 0 2.84300000000004e-06 0 2.84305000000004e-06 0 2.84400000000004e-06 0 2.84405000000004e-06 0 2.84500000000004e-06 0 2.84505000000004e-06 0 2.84900000000004e-06 0 2.84905000000004e-06 0 2.85000000000004e-06 0 2.85005000000004e-06 0 2.85100000000004e-06 0 2.85105000000004e-06 0 2.85500000000004e-06 0 2.85505000000004e-06 0 2.85600000000004e-06 0 2.85605000000004e-06 0 2.85700000000004e-06 0 2.85705000000004e-06 0 2.86100000000004e-06 0 2.86105000000004e-06 0 2.86200000000004e-06 0 2.86205000000004e-06 0 2.86300000000004e-06 0 2.86305000000004e-06 0 2.86700000000004e-06 0 2.86705000000004e-06 0 2.86800000000004e-06 0 2.86805000000004e-06 0 2.86900000000004e-06 0 2.86905000000004e-06 0 2.87300000000004e-06 0 2.87305000000004e-06 0 2.87400000000004e-06 0 2.87405000000004e-06 0 2.87500000000004e-06 0 2.87505000000004e-06 0 2.87900000000004e-06 0 2.87905000000004e-06 0 2.88000000000004e-06 0 2.88005000000004e-06 0 2.88100000000004e-06 0 2.88110000000004e-06 1 2.88500000000004e-06 1 2.88505000000004e-06 0 2.88600000000004e-06 0 2.88605000000004e-06 0 2.88700000000004e-06 0 2.88710000000004e-06 1 2.89100000000004e-06 1 2.89105000000004e-06 0 2.89200000000004e-06 0 2.89205000000004e-06 0 2.89300000000004e-06 0 2.89310000000004e-06 1 2.89700000000004e-06 1 2.89705000000004e-06 0 2.89800000000004e-06 0 2.89805000000004e-06 0 2.89900000000004e-06 0 2.89910000000004e-06 1 2.90300000000004e-06 1 2.90305000000004e-06 0 2.90400000000004e-06 0 2.90405000000004e-06 0 2.90500000000004e-06 0 2.90510000000004e-06 1 2.90900000000004e-06 1 2.90905000000004e-06 0 2.91000000000004e-06 0 2.91005000000004e-06 0 2.91100000000004e-06 0 2.91110000000004e-06 1 2.91500000000004e-06 1 2.91505000000004e-06 0 2.91600000000004e-06 0 2.91605000000004e-06 0 2.91700000000004e-06 0 2.91710000000004e-06 1 2.92100000000004e-06 1 2.92105000000004e-06 0 2.92200000000004e-06 0 2.92205000000004e-06 0 2.92300000000004e-06 0 2.92310000000004e-06 1 2.92700000000004e-06 1 2.92705000000004e-06 0 2.92800000000004e-06 0 2.92805000000004e-06 0 2.92900000000004e-06 0 2.92910000000004e-06 1 2.93300000000004e-06 1 2.93305000000004e-06 0 2.93400000000004e-06 0 2.93405000000004e-06 0 2.93500000000004e-06 0 2.93510000000004e-06 1 2.93900000000004e-06 1 2.93905000000004e-06 0 2.94000000000004e-06 0 2.94005000000004e-06 0 2.94100000000004e-06 0 2.94110000000004e-06 1 2.94500000000004e-06 1 2.94505000000004e-06 0 2.94600000000004e-06 0 2.94605000000004e-06 0 2.94700000000004e-06 0 2.94710000000004e-06 1 2.95100000000004e-06 1 2.95105000000004e-06 0 2.95200000000004e-06 0 2.95205000000004e-06 0 2.95300000000004e-06 0 2.95310000000004e-06 1 2.95700000000004e-06 1 2.95705000000004e-06 0 2.95800000000004e-06 0 2.95805000000004e-06 0 2.95900000000004e-06 0 2.95910000000004e-06 1 2.96300000000004e-06 1 2.96305000000004e-06 0 2.96400000000004e-06 0 2.96405000000004e-06 0 2.96500000000004e-06 0 2.96510000000004e-06 1 2.96900000000004e-06 1 2.96905000000004e-06 0 2.97000000000004e-06 0 2.97005000000004e-06 0 2.97100000000004e-06 0 2.97110000000004e-06 1 2.97500000000004e-06 1 2.97505000000004e-06 0 2.97600000000004e-06 0 2.97605000000004e-06 0 2.97700000000004e-06 0 2.97710000000004e-06 1 2.98100000000004e-06 1 2.98105000000004e-06 0 2.98200000000004e-06 0 2.98205000000004e-06 0 2.98300000000004e-06 0 2.98310000000004e-06 1 2.98700000000004e-06 1 2.98705000000004e-06 0 2.98800000000004e-06 0 2.98805000000004e-06 0 2.98900000000004e-06 0 2.98910000000004e-06 1 2.99300000000004e-06 1 2.99305000000004e-06 0 2.99400000000004e-06 0 2.99405000000004e-06 0 2.99500000000004e-06 0 2.99510000000004e-06 1 2.99900000000004e-06 1 2.99905000000004e-06 0 3.00000000000004e-06 0 3.00005000000004e-06 0 3.00100000000004e-06 0 3.00110000000004e-06 1 3.00500000000004e-06 1 3.00505000000004e-06 0 3.00600000000004e-06 0 3.00605000000004e-06 0 3.00700000000004e-06 0 3.00710000000004e-06 1 3.01100000000004e-06 1 3.01105000000004e-06 0 3.01200000000004e-06 0 3.01205000000004e-06 0 3.01300000000004e-06 0 3.01310000000004e-06 1 3.01700000000004e-06 1 3.01705000000004e-06 0 3.01800000000004e-06 0 3.01805000000004e-06 0 3.01900000000004e-06 0 3.01910000000004e-06 1 3.02300000000004e-06 1 3.02305000000004e-06 0 3.02400000000004e-06 0 3.02405000000004e-06 0 3.02500000000004e-06 0 3.02510000000004e-06 1 3.02900000000004e-06 1 3.02905000000004e-06 0 3.03000000000004e-06 0 3.03005000000004e-06 0 3.03100000000004e-06 0 3.03110000000004e-06 1 3.03500000000004e-06 1 3.03505000000004e-06 0 3.03600000000004e-06 0 3.03605000000004e-06 0 3.03700000000004e-06 0 3.03710000000004e-06 1 3.04100000000004e-06 1 3.04105000000004e-06 0 3.04200000000004e-06 0 3.04205000000004e-06 0 3.04300000000004e-06 0 3.04310000000004e-06 1 3.04700000000004e-06 1 3.04705000000004e-06 0 3.04800000000004e-06 0 3.04805000000004e-06 0 3.04900000000004e-06 0 3.04910000000004e-06 1 3.05300000000004e-06 1 3.05305000000004e-06 0 3.05400000000004e-06 0 3.05405000000004e-06 0 3.05500000000004e-06 0 3.05510000000004e-06 1 3.05900000000004e-06 1 3.05905000000004e-06 0 3.06000000000004e-06 0 3.06005000000004e-06 0 3.06100000000004e-06 0 3.06110000000004e-06 1 3.06500000000004e-06 1 3.06505000000004e-06 0 3.06600000000004e-06 0 3.06605000000004e-06 0 3.06700000000004e-06 0 3.06710000000004e-06 1 3.07100000000004e-06 1 3.07105000000004e-06 0 3.07650000000004e-06 0]
parameters wave_SA_SH = [0 0 4e-09 0 4.1e-09 1 4.5e-09 1 4.55e-09 0 6e-09 0 6.05e-09 0 1e-08 0 1.01e-08 1 1.05e-08 1 1.055e-08 0 1.2e-08 0 1.205e-08 0 1.6e-08 0 1.61e-08 1 1.65e-08 1 1.655e-08 0 1.8e-08 0 1.805e-08 0 2.2e-08 0 2.21e-08 1 2.25e-08 1 2.255e-08 0 2.4e-08 0 2.405e-08 0 2.8e-08 0 2.81e-08 1 2.85e-08 1 2.855e-08 0 3e-08 0 3.005e-08 0 3.4e-08 0 3.41e-08 1 3.45e-08 1 3.455e-08 0 3.6e-08 0 3.605e-08 0 4e-08 0 4.01e-08 1 4.05e-08 1 4.055e-08 0 4.2e-08 0 4.205e-08 0 4.6e-08 0 4.61e-08 1 4.65e-08 1 4.655e-08 0 4.8e-08 0 4.805e-08 0 5.2e-08 0 5.21e-08 1 5.25e-08 1 5.255e-08 0 5.4e-08 0 5.405e-08 0 5.8e-08 0 5.81e-08 1 5.85e-08 1 5.855e-08 0 6e-08 0 6.005e-08 0 6.4e-08 0 6.41e-08 1 6.45e-08 1 6.455e-08 0 6.6e-08 0 6.605e-08 0 7e-08 0 7.01e-08 1 7.05e-08 1 7.055e-08 0 7.2e-08 0 7.205e-08 0 7.6e-08 0 7.61e-08 1 7.65e-08 1 7.655e-08 0 7.8e-08 0 7.805e-08 0 8.2e-08 0 8.21e-08 1 8.25e-08 1 8.255e-08 0 8.4e-08 0 8.405e-08 0 8.8e-08 0 8.81e-08 1 8.85e-08 1 8.855e-08 0 9e-08 0 9.005e-08 0 9.4e-08 0 9.41e-08 1 9.45e-08 1 9.455e-08 0 9.6e-08 0 9.605e-08 0 1e-07 0 1.001e-07 1 1.005e-07 1 1.0055e-07 0 1.02e-07 0 1.0205e-07 0 1.06e-07 0 1.061e-07 1 1.065e-07 1 1.0655e-07 0 1.08e-07 0 1.0805e-07 0 1.12e-07 0 1.121e-07 1 1.125e-07 1 1.1255e-07 0 1.14e-07 0 1.1405e-07 0 1.18e-07 0 1.181e-07 1 1.185e-07 1 1.1855e-07 0 1.2e-07 0 1.2005e-07 0 1.24e-07 0 1.241e-07 1 1.245e-07 1 1.2455e-07 0 1.26e-07 0 1.2605e-07 0 1.3e-07 0 1.301e-07 1 1.305e-07 1 1.3055e-07 0 1.32e-07 0 1.3205e-07 0 1.36e-07 0 1.361e-07 1 1.365e-07 1 1.3655e-07 0 1.38e-07 0 1.3805e-07 0 1.42e-07 0 1.421e-07 1 1.425e-07 1 1.4255e-07 0 1.44e-07 0 1.4405e-07 0 1.48e-07 0 1.481e-07 1 1.485e-07 1 1.4855e-07 0 1.5e-07 0 1.5005e-07 0 1.54e-07 0 1.541e-07 1 1.545e-07 1 1.5455e-07 0 1.56e-07 0 1.5605e-07 0 1.6e-07 0 1.601e-07 1 1.605e-07 1 1.6055e-07 0 1.62e-07 0 1.6205e-07 0 1.66e-07 0 1.661e-07 1 1.665e-07 1 1.6655e-07 0 1.68e-07 0 1.6805e-07 0 1.72e-07 0 1.721e-07 1 1.725e-07 1 1.7255e-07 0 1.74e-07 0 1.7405e-07 0 1.78e-07 0 1.781e-07 1 1.785e-07 1 1.7855e-07 0 1.8e-07 0 1.8005e-07 0 1.84e-07 0 1.841e-07 1 1.845e-07 1 1.8455e-07 0 1.86e-07 0 1.8605e-07 0 1.9e-07 0 1.901e-07 1 1.905e-07 1 1.9055e-07 0 1.92e-07 0 1.9205e-07 0 1.96e-07 0 1.961e-07 1 1.965e-07 1 1.9655e-07 0 1.98e-07 0 1.9805e-07 0 2.02e-07 0 2.021e-07 1 2.025e-07 1 2.0255e-07 0 2.04e-07 0 2.0405e-07 0 2.08e-07 0 2.081e-07 1 2.085e-07 1 2.0855e-07 0 2.1e-07 0 2.1005e-07 0 2.14e-07 0 2.141e-07 1 2.145e-07 1 2.1455e-07 0 2.16e-07 0 2.1605e-07 0 2.2e-07 0 2.201e-07 1 2.205e-07 1 2.2055e-07 0 2.22e-07 0 2.2205e-07 0 2.26e-07 0 2.261e-07 1 2.265e-07 1 2.26550000000001e-07 0 2.28000000000001e-07 0 2.28050000000001e-07 0 2.32000000000001e-07 0 2.32100000000001e-07 1 2.32500000000001e-07 1 2.32550000000001e-07 0 2.34000000000001e-07 0 2.34050000000001e-07 0 2.38000000000001e-07 0 2.38100000000001e-07 1 2.38500000000001e-07 1 2.38550000000001e-07 0 2.40000000000001e-07 0 2.40050000000001e-07 0 2.44000000000001e-07 0 2.44100000000001e-07 1 2.44500000000001e-07 1 2.44550000000001e-07 0 2.46000000000001e-07 0 2.46050000000001e-07 0 2.50000000000001e-07 0 2.50100000000001e-07 1 2.50500000000001e-07 1 2.50550000000001e-07 0 2.52000000000001e-07 0 2.52050000000001e-07 0 2.56e-07 0 2.561e-07 1 2.565e-07 1 2.5655e-07 0 2.58e-07 0 2.5805e-07 0 2.62e-07 0 2.621e-07 1 2.625e-07 1 2.6255e-07 0 2.64e-07 0 2.6405e-07 0 2.68e-07 0 2.681e-07 1 2.685e-07 1 2.6855e-07 0 2.7e-07 0 2.7005e-07 0 2.74e-07 0 2.741e-07 1 2.745e-07 1 2.7455e-07 0 2.76e-07 0 2.7605e-07 0 2.8e-07 0 2.801e-07 1 2.805e-07 1 2.8055e-07 0 2.82e-07 0 2.8205e-07 0 2.86e-07 0 2.861e-07 1 2.865e-07 1 2.8655e-07 0 2.88e-07 0 2.8805e-07 0 2.92e-07 0 2.921e-07 1 2.925e-07 1 2.9255e-07 0 2.94e-07 0 2.9405e-07 0 2.98e-07 0 2.981e-07 1 2.985e-07 1 2.9855e-07 0 3e-07 0 3.0005e-07 0 3.04e-07 0 3.041e-07 1 3.045e-07 1 3.0455e-07 0 3.06e-07 0 3.0605e-07 0 3.1e-07 0 3.101e-07 1 3.105e-07 1 3.1055e-07 0 3.12e-07 0 3.1205e-07 0 3.16e-07 0 3.161e-07 1 3.165e-07 1 3.1655e-07 0 3.18e-07 0 3.1805e-07 0 3.22e-07 0 3.221e-07 1 3.225e-07 1 3.2255e-07 0 3.24e-07 0 3.2405e-07 0 3.28e-07 0 3.281e-07 1 3.285e-07 1 3.2855e-07 0 3.3e-07 0 3.3005e-07 0 3.34e-07 0 3.341e-07 1 3.345e-07 1 3.3455e-07 0 3.36e-07 0 3.3605e-07 0 3.4e-07 0 3.401e-07 1 3.405e-07 1 3.4055e-07 0 3.42e-07 0 3.4205e-07 0 3.46e-07 0 3.461e-07 1 3.465e-07 1 3.4655e-07 0 3.48e-07 0 3.4805e-07 0 3.52e-07 0 3.521e-07 1 3.525e-07 1 3.5255e-07 0 3.54e-07 0 3.5405e-07 0 3.58e-07 0 3.581e-07 1 3.585e-07 1 3.5855e-07 0 3.6e-07 0 3.6005e-07 0 3.64e-07 0 3.641e-07 1 3.645e-07 1 3.6455e-07 0 3.66e-07 0 3.6605e-07 0 3.7e-07 0 3.701e-07 1 3.705e-07 1 3.7055e-07 0 3.72e-07 0 3.7205e-07 0 3.76e-07 0 3.761e-07 1 3.765e-07 1 3.7655e-07 0 3.78e-07 0 3.7805e-07 0 3.82e-07 0 3.821e-07 1 3.825e-07 1 3.8255e-07 0 3.84e-07 0 3.8405e-07 0 3.88e-07 0 3.881e-07 1 3.885e-07 1 3.8855e-07 0 3.9e-07 0 3.9005e-07 0 3.94e-07 0 3.941e-07 1 3.945e-07 1 3.9455e-07 0 3.96e-07 0 3.9605e-07 0 4e-07 0 4.001e-07 1 4.005e-07 1 4.0055e-07 0 4.02e-07 0 4.0205e-07 0 4.06e-07 0 4.061e-07 1 4.065e-07 1 4.0655e-07 0 4.08e-07 0 4.0805e-07 0 4.12e-07 0 4.121e-07 1 4.125e-07 1 4.1255e-07 0 4.14e-07 0 4.1405e-07 0 4.18e-07 0 4.181e-07 1 4.185e-07 1 4.1855e-07 0 4.2e-07 0 4.2005e-07 0 4.24e-07 0 4.241e-07 1 4.245e-07 1 4.2455e-07 0 4.26e-07 0 4.2605e-07 0 4.3e-07 0 4.301e-07 1 4.305e-07 1 4.3055e-07 0 4.32e-07 0 4.3205e-07 0 4.36e-07 0 4.361e-07 1 4.365e-07 1 4.3655e-07 0 4.38e-07 0 4.3805e-07 0 4.42e-07 0 4.421e-07 1 4.425e-07 1 4.4255e-07 0 4.44e-07 0 4.4405e-07 0 4.48e-07 0 4.481e-07 1 4.485e-07 1 4.4855e-07 0 4.5e-07 0 4.5005e-07 0 4.54e-07 0 4.541e-07 1 4.545e-07 1 4.5455e-07 0 4.56e-07 0 4.5605e-07 0 4.6e-07 0 4.601e-07 1 4.605e-07 1 4.6055e-07 0 4.62e-07 0 4.6205e-07 0 4.66e-07 0 4.661e-07 1 4.665e-07 1 4.6655e-07 0 4.68e-07 0 4.6805e-07 0 4.72e-07 0 4.721e-07 1 4.725e-07 1 4.7255e-07 0 4.74e-07 0 4.7405e-07 0 4.78e-07 0 4.781e-07 1 4.785e-07 1 4.7855e-07 0 4.8e-07 0 4.8005e-07 0 4.84e-07 0 4.841e-07 1 4.845e-07 1 4.8455e-07 0 4.86e-07 0 4.8605e-07 0 4.9e-07 0 4.901e-07 1 4.905e-07 1 4.9055e-07 0 4.92e-07 0 4.9205e-07 0 4.96e-07 0 4.961e-07 1 4.965e-07 1 4.9655e-07 0 4.98e-07 0 4.9805e-07 0 5.02e-07 0 5.021e-07 1 5.025e-07 1 5.0255e-07 0 5.04e-07 0 5.0405e-07 0 5.08e-07 0 5.081e-07 1 5.085e-07 1 5.0855e-07 0 5.1e-07 0 5.1005e-07 0 5.14e-07 0 5.141e-07 1 5.145e-07 1 5.1455e-07 0 5.16e-07 0 5.1605e-07 0 5.2e-07 0 5.201e-07 1 5.205e-07 1 5.2055e-07 0 5.22e-07 0 5.2205e-07 0 5.26e-07 0 5.261e-07 1 5.265e-07 1 5.2655e-07 0 5.28e-07 0 5.2805e-07 0 5.32e-07 0 5.321e-07 1 5.325e-07 1 5.3255e-07 0 5.34e-07 0 5.3405e-07 0 5.38e-07 0 5.381e-07 1 5.385e-07 1 5.3855e-07 0 5.4e-07 0 5.4005e-07 0 5.44e-07 0 5.441e-07 1 5.445e-07 1 5.4455e-07 0 5.46e-07 0 5.4605e-07 0 5.5e-07 0 5.501e-07 1 5.505e-07 1 5.5055e-07 0 5.52e-07 0 5.5205e-07 0 5.56e-07 0 5.561e-07 1 5.565e-07 1 5.5655e-07 0 5.58e-07 0 5.5805e-07 0 5.62e-07 0 5.621e-07 1 5.625e-07 1 5.6255e-07 0 5.64e-07 0 5.6405e-07 0 5.68e-07 0 5.681e-07 1 5.685e-07 1 5.6855e-07 0 5.7e-07 0 5.7005e-07 0 5.74e-07 0 5.741e-07 1 5.745e-07 1 5.7455e-07 0 5.76e-07 0 5.7605e-07 0 5.8e-07 0 5.801e-07 1 5.805e-07 1 5.8055e-07 0 5.82e-07 0 5.8205e-07 0 5.86e-07 0 5.861e-07 1 5.865e-07 1 5.8655e-07 0 5.88e-07 0 5.8805e-07 0 5.92e-07 0 5.921e-07 1 5.925e-07 1 5.9255e-07 0 5.94e-07 0 5.9405e-07 0 5.98e-07 0 5.981e-07 1 5.985e-07 1 5.9855e-07 0 6e-07 0 6.0005e-07 0 6.04e-07 0 6.041e-07 1 6.045e-07 1 6.0455e-07 0 6.06e-07 0 6.0605e-07 0 6.1e-07 0 6.101e-07 1 6.105e-07 1 6.1055e-07 0 6.12e-07 0 6.1205e-07 0 6.16e-07 0 6.161e-07 1 6.165e-07 1 6.1655e-07 0 6.18e-07 0 6.1805e-07 0 6.22e-07 0 6.221e-07 1 6.225e-07 1 6.2255e-07 0 6.24e-07 0 6.2405e-07 0 6.28e-07 0 6.281e-07 1 6.285e-07 1 6.2855e-07 0 6.3e-07 0 6.3005e-07 0 6.34e-07 0 6.341e-07 1 6.345e-07 1 6.3455e-07 0 6.36e-07 0 6.3605e-07 0 6.4e-07 0 6.401e-07 1 6.405e-07 1 6.4055e-07 0 6.42e-07 0 6.4205e-07 0 6.46e-07 0 6.461e-07 1 6.465e-07 1 6.4655e-07 0 6.48e-07 0 6.4805e-07 0 6.52e-07 0 6.521e-07 1 6.525e-07 1 6.5255e-07 0 6.54e-07 0 6.5405e-07 0 6.58e-07 0 6.581e-07 1 6.585e-07 1 6.5855e-07 0 6.6e-07 0 6.6005e-07 0 6.64e-07 0 6.641e-07 1 6.645e-07 1 6.6455e-07 0 6.66e-07 0 6.6605e-07 0 6.7e-07 0 6.701e-07 1 6.70500000000001e-07 1 6.70550000000001e-07 0 6.72000000000001e-07 0 6.72050000000001e-07 0 6.76e-07 0 6.76100000000001e-07 1 6.76500000000001e-07 1 6.76550000000001e-07 0 6.78000000000001e-07 0 6.78050000000001e-07 0 6.82000000000001e-07 0 6.82100000000001e-07 1 6.82500000000001e-07 1 6.82550000000001e-07 0 6.84000000000001e-07 0 6.84050000000001e-07 0 6.88000000000001e-07 0 6.88100000000001e-07 1 6.88500000000001e-07 1 6.88550000000001e-07 0 6.90000000000001e-07 0 6.90050000000001e-07 0 6.94000000000001e-07 0 6.94100000000001e-07 1 6.94500000000001e-07 1 6.94550000000001e-07 0 6.96000000000001e-07 0 6.96050000000001e-07 0 7.00000000000001e-07 0 7.00100000000001e-07 1 7.00500000000001e-07 1 7.00550000000001e-07 0 7.02000000000001e-07 0 7.02050000000001e-07 0 7.06000000000001e-07 0 7.06100000000001e-07 1 7.06500000000001e-07 1 7.06550000000001e-07 0 7.08000000000001e-07 0 7.08050000000001e-07 0 7.12000000000001e-07 0 7.12100000000001e-07 1 7.12500000000001e-07 1 7.12550000000001e-07 0 7.14000000000001e-07 0 7.14050000000001e-07 0 7.18000000000001e-07 0 7.18100000000001e-07 1 7.18500000000001e-07 1 7.18550000000001e-07 0 7.20000000000001e-07 0 7.20050000000001e-07 0 7.24000000000001e-07 0 7.24100000000001e-07 1 7.24500000000001e-07 1 7.24550000000001e-07 0 7.26000000000001e-07 0 7.26050000000001e-07 0 7.30000000000001e-07 0 7.30100000000001e-07 1 7.30500000000001e-07 1 7.30550000000001e-07 0 7.32000000000001e-07 0 7.32050000000001e-07 0 7.36000000000001e-07 0 7.36100000000001e-07 1 7.36500000000001e-07 1 7.36550000000001e-07 0 7.38000000000001e-07 0 7.38050000000001e-07 0 7.42000000000001e-07 0 7.42100000000001e-07 1 7.42500000000001e-07 1 7.42550000000001e-07 0 7.44000000000001e-07 0 7.44050000000001e-07 0 7.48000000000001e-07 0 7.48100000000001e-07 1 7.48500000000001e-07 1 7.48550000000001e-07 0 7.50000000000001e-07 0 7.50050000000001e-07 0 7.54000000000001e-07 0 7.54100000000001e-07 1 7.54500000000001e-07 1 7.54550000000001e-07 0 7.56000000000001e-07 0 7.56050000000001e-07 0 7.60000000000001e-07 0 7.60100000000001e-07 1 7.60500000000001e-07 1 7.60550000000001e-07 0 7.62000000000001e-07 0 7.62050000000001e-07 0 7.66000000000001e-07 0 7.66100000000001e-07 1 7.66500000000001e-07 1 7.66550000000001e-07 0 7.68000000000001e-07 0 7.68050000000001e-07 0 7.72000000000001e-07 0 7.72100000000001e-07 1 7.72500000000001e-07 1 7.72550000000001e-07 0 7.74000000000001e-07 0 7.74050000000001e-07 0 7.78000000000001e-07 0 7.78100000000001e-07 1 7.78500000000001e-07 1 7.78550000000001e-07 0 7.80000000000001e-07 0 7.80050000000001e-07 0 7.84000000000001e-07 0 7.84100000000001e-07 1 7.84500000000001e-07 1 7.84550000000001e-07 0 7.86000000000001e-07 0 7.86050000000001e-07 0 7.90000000000001e-07 0 7.90100000000001e-07 1 7.90500000000001e-07 1 7.90550000000001e-07 0 7.92000000000001e-07 0 7.92050000000001e-07 0 7.96000000000001e-07 0 7.96100000000001e-07 1 7.96500000000001e-07 1 7.96550000000001e-07 0 7.98000000000001e-07 0 7.98050000000001e-07 0 8.02000000000001e-07 0 8.02100000000001e-07 1 8.02500000000001e-07 1 8.02550000000001e-07 0 8.04000000000001e-07 0 8.04050000000001e-07 0 8.08000000000001e-07 0 8.08100000000001e-07 1 8.08500000000001e-07 1 8.08550000000001e-07 0 8.10000000000001e-07 0 8.10050000000001e-07 0 8.14000000000001e-07 0 8.14100000000001e-07 1 8.14500000000001e-07 1 8.14550000000001e-07 0 8.16000000000001e-07 0 8.16050000000001e-07 0 8.20000000000001e-07 0 8.20100000000001e-07 1 8.20500000000001e-07 1 8.20550000000001e-07 0 8.22000000000001e-07 0 8.22050000000001e-07 0 8.26000000000001e-07 0 8.26100000000001e-07 1 8.26500000000001e-07 1 8.26550000000001e-07 0 8.28000000000001e-07 0 8.28050000000001e-07 0 8.32000000000001e-07 0 8.32100000000001e-07 1 8.32500000000001e-07 1 8.32550000000001e-07 0 8.34000000000001e-07 0 8.34050000000001e-07 0 8.38000000000001e-07 0 8.38100000000001e-07 1 8.38500000000001e-07 1 8.38550000000001e-07 0 8.40000000000001e-07 0 8.40050000000001e-07 0 8.44000000000001e-07 0 8.44100000000001e-07 1 8.44500000000001e-07 1 8.44550000000001e-07 0 8.46000000000001e-07 0 8.46050000000001e-07 0 8.50000000000001e-07 0 8.50100000000001e-07 1 8.50500000000001e-07 1 8.50550000000001e-07 0 8.52000000000001e-07 0 8.52050000000001e-07 0 8.56000000000001e-07 0 8.56100000000001e-07 1 8.56500000000001e-07 1 8.56550000000001e-07 0 8.58000000000001e-07 0 8.58050000000001e-07 0 8.62000000000001e-07 0 8.62100000000001e-07 1 8.62500000000001e-07 1 8.62550000000001e-07 0 8.64000000000001e-07 0 8.64050000000001e-07 0 8.68000000000001e-07 0 8.68100000000001e-07 1 8.68500000000001e-07 1 8.68550000000001e-07 0 8.70000000000001e-07 0 8.70050000000001e-07 0 8.74000000000001e-07 0 8.74100000000001e-07 1 8.74500000000001e-07 1 8.74550000000001e-07 0 8.76000000000001e-07 0 8.76050000000001e-07 0 8.80000000000001e-07 0 8.80100000000001e-07 1 8.80500000000001e-07 1 8.80550000000001e-07 0 8.82000000000001e-07 0 8.82050000000001e-07 0 8.86000000000001e-07 0 8.86100000000001e-07 1 8.86500000000001e-07 1 8.86550000000001e-07 0 8.88000000000001e-07 0 8.88050000000001e-07 0 8.92000000000001e-07 0 8.92100000000001e-07 1 8.92500000000002e-07 1 8.92550000000002e-07 0 8.94000000000002e-07 0 8.94050000000002e-07 0 8.98000000000002e-07 0 8.98100000000002e-07 1 8.98500000000002e-07 1 8.98550000000002e-07 0 9.00000000000002e-07 0 9.00050000000002e-07 0 9.04000000000002e-07 0 9.04100000000002e-07 1 9.04500000000002e-07 1 9.04550000000002e-07 0 9.06000000000002e-07 0 9.06050000000002e-07 0 9.10000000000002e-07 0 9.10100000000002e-07 1 9.10500000000002e-07 1 9.10550000000002e-07 0 9.12000000000002e-07 0 9.12050000000002e-07 0 9.16000000000002e-07 0 9.16100000000002e-07 1 9.16500000000002e-07 1 9.16550000000002e-07 0 9.18000000000002e-07 0 9.18050000000002e-07 0 9.22000000000002e-07 0 9.22100000000002e-07 1 9.22500000000002e-07 1 9.22550000000002e-07 0 9.24000000000002e-07 0 9.24050000000002e-07 0 9.28000000000002e-07 0 9.28100000000002e-07 1 9.28500000000002e-07 1 9.28550000000002e-07 0 9.30000000000002e-07 0 9.30050000000002e-07 0 9.34000000000002e-07 0 9.34100000000002e-07 1 9.34500000000002e-07 1 9.34550000000002e-07 0 9.36000000000002e-07 0 9.36050000000002e-07 0 9.40000000000002e-07 0 9.40100000000002e-07 1 9.40500000000002e-07 1 9.40550000000002e-07 0 9.42000000000002e-07 0 9.42050000000002e-07 0 9.46000000000002e-07 0 9.46100000000002e-07 1 9.46500000000002e-07 1 9.46550000000002e-07 0 9.48000000000002e-07 0 9.48050000000002e-07 0 9.52000000000002e-07 0 9.52100000000002e-07 1 9.52500000000002e-07 1 9.52550000000002e-07 0 9.54000000000002e-07 0 9.54050000000002e-07 0 9.58000000000002e-07 0 9.58100000000002e-07 1 9.58500000000002e-07 1 9.58550000000002e-07 0 9.60000000000002e-07 0 9.60050000000002e-07 0 9.64000000000002e-07 0 9.64100000000002e-07 1 9.64500000000002e-07 1 9.64550000000002e-07 0 9.66000000000002e-07 0 9.66050000000002e-07 0 9.70000000000002e-07 0 9.70100000000002e-07 1 9.70500000000002e-07 1 9.70550000000002e-07 0 9.72000000000002e-07 0 9.72050000000002e-07 0 9.76000000000002e-07 0 9.76100000000002e-07 1 9.76500000000002e-07 1 9.76550000000002e-07 0 9.78000000000002e-07 0 9.78050000000002e-07 0 9.82000000000002e-07 0 9.82100000000002e-07 1 9.82500000000002e-07 1 9.82550000000002e-07 0 9.84000000000002e-07 0 9.84050000000002e-07 0 9.88000000000002e-07 0 9.88100000000002e-07 1 9.88500000000002e-07 1 9.88550000000002e-07 0 9.90000000000002e-07 0 9.90050000000002e-07 0 9.94000000000002e-07 0 9.94100000000002e-07 1 9.94500000000002e-07 1 9.94550000000002e-07 0 9.96000000000002e-07 0 9.96050000000002e-07 0 1e-06 0 1.0001e-06 1 1.0005e-06 1 1.00055e-06 0 1.002e-06 0 1.00205e-06 0 1.006e-06 0 1.0061e-06 1 1.0065e-06 1 1.00655e-06 0 1.008e-06 0 1.00805e-06 0 1.012e-06 0 1.0121e-06 1 1.0125e-06 1 1.01255e-06 0 1.014e-06 0 1.01405e-06 0 1.018e-06 0 1.0181e-06 1 1.0185e-06 1 1.01855e-06 0 1.02e-06 0 1.02005e-06 0 1.024e-06 0 1.0241e-06 1 1.0245e-06 1 1.02455e-06 0 1.026e-06 0 1.02605e-06 0 1.03e-06 0 1.0301e-06 1 1.0305e-06 1 1.03055e-06 0 1.032e-06 0 1.03205e-06 0 1.036e-06 0 1.0361e-06 1 1.0365e-06 1 1.03655e-06 0 1.038e-06 0 1.03805e-06 0 1.042e-06 0 1.0421e-06 1 1.0425e-06 1 1.04255e-06 0 1.044e-06 0 1.04405e-06 0 1.048e-06 0 1.0481e-06 1 1.0485e-06 1 1.04855e-06 0 1.05e-06 0 1.05005e-06 0 1.054e-06 0 1.0541e-06 1 1.0545e-06 1 1.05455e-06 0 1.056e-06 0 1.05605e-06 0 1.06e-06 0 1.0601e-06 1 1.0605e-06 1 1.06055e-06 0 1.062e-06 0 1.06205e-06 0 1.066e-06 0 1.0661e-06 1 1.0665e-06 1 1.06655e-06 0 1.068e-06 0 1.06805e-06 0 1.072e-06 0 1.0721e-06 1 1.0725e-06 1 1.07255e-06 0 1.074e-06 0 1.07405e-06 0 1.078e-06 0 1.0781e-06 1 1.0785e-06 1 1.07855e-06 0 1.08e-06 0 1.08005e-06 0 1.084e-06 0 1.0841e-06 1 1.0845e-06 1 1.08455e-06 0 1.086e-06 0 1.08605e-06 0 1.09e-06 0 1.0901e-06 1 1.0905e-06 1 1.09055e-06 0 1.092e-06 0 1.09205e-06 0 1.096e-06 0 1.0961e-06 1 1.0965e-06 1 1.09655e-06 0 1.098e-06 0 1.09805e-06 0 1.102e-06 0 1.1021e-06 1 1.1025e-06 1 1.10255e-06 0 1.104e-06 0 1.10405e-06 0 1.108e-06 0 1.1081e-06 1 1.1085e-06 1 1.10855e-06 0 1.11e-06 0 1.11005e-06 0 1.114e-06 0 1.1141e-06 1 1.1145e-06 1 1.11455e-06 0 1.116e-06 0 1.11605e-06 0 1.12e-06 0 1.1201e-06 1 1.1205e-06 1 1.12055e-06 0 1.122e-06 0 1.12205e-06 0 1.126e-06 0 1.1261e-06 1 1.1265e-06 1 1.12655e-06 0 1.128e-06 0 1.12805e-06 0 1.132e-06 0 1.1321e-06 1 1.1325e-06 1 1.13255e-06 0 1.134e-06 0 1.13405e-06 0 1.138e-06 0 1.1381e-06 1 1.1385e-06 1 1.13855e-06 0 1.14e-06 0 1.14005e-06 0 1.144e-06 0 1.1441e-06 1 1.1445e-06 1 1.14455e-06 0 1.146e-06 0 1.14605e-06 0 1.15e-06 0 1.1501e-06 1 1.1505e-06 1 1.15055e-06 0 1.152e-06 0 1.15205e-06 0 1.156e-06 0 1.1561e-06 1 1.1565e-06 1 1.15655e-06 0 1.158e-06 0 1.15805e-06 0 1.162e-06 0 1.1621e-06 1 1.1625e-06 1 1.16255e-06 0 1.164e-06 0 1.16405e-06 0 1.168e-06 0 1.1681e-06 1 1.1685e-06 1 1.16855e-06 0 1.17e-06 0 1.17005e-06 0 1.174e-06 0 1.1741e-06 1 1.1745e-06 1 1.17455e-06 0 1.176e-06 0 1.17605e-06 0 1.18e-06 0 1.1801e-06 1 1.1805e-06 1 1.18055e-06 0 1.182e-06 0 1.18205e-06 0 1.186e-06 0 1.1861e-06 1 1.1865e-06 1 1.18655e-06 0 1.188e-06 0 1.18805e-06 0 1.192e-06 0 1.1921e-06 1 1.1925e-06 1 1.19255e-06 0 1.194e-06 0 1.19405e-06 0 1.198e-06 0 1.1981e-06 1 1.1985e-06 1 1.19855e-06 0 1.2e-06 0 1.20005e-06 0 1.204e-06 0 1.2041e-06 1 1.2045e-06 1 1.20455e-06 0 1.206e-06 0 1.20605e-06 0 1.21e-06 0 1.2101e-06 1 1.2105e-06 1 1.21055e-06 0 1.212e-06 0 1.21205e-06 0 1.216e-06 0 1.2161e-06 1 1.2165e-06 1 1.21655e-06 0 1.218e-06 0 1.21805e-06 0 1.222e-06 0 1.2221e-06 1 1.2225e-06 1 1.22255e-06 0 1.224e-06 0 1.22405e-06 0 1.228e-06 0 1.2281e-06 1 1.2285e-06 1 1.22855e-06 0 1.23e-06 0 1.23005e-06 0 1.234e-06 0 1.2341e-06 1 1.2345e-06 1 1.23455e-06 0 1.236e-06 0 1.23605e-06 0 1.24e-06 0 1.2401e-06 1 1.2405e-06 1 1.24055e-06 0 1.242e-06 0 1.24205e-06 0 1.246e-06 0 1.2461e-06 1 1.2465e-06 1 1.24655e-06 0 1.248e-06 0 1.24805e-06 0 1.252e-06 0 1.2521e-06 1 1.2525e-06 1 1.25255e-06 0 1.254e-06 0 1.25405e-06 0 1.258e-06 0 1.2581e-06 1 1.2585e-06 1 1.25855e-06 0 1.26e-06 0 1.26005e-06 0 1.264e-06 0 1.2641e-06 1 1.2645e-06 1 1.26455e-06 0 1.266e-06 0 1.26605e-06 0 1.27e-06 0 1.2701e-06 1 1.2705e-06 1 1.27055e-06 0 1.272e-06 0 1.27205e-06 0 1.276e-06 0 1.2761e-06 1 1.2765e-06 1 1.27655e-06 0 1.278e-06 0 1.27805e-06 0 1.282e-06 0 1.2821e-06 1 1.2825e-06 1 1.28255e-06 0 1.284e-06 0 1.28405e-06 0 1.288e-06 0 1.2881e-06 1 1.2885e-06 1 1.28855e-06 0 1.29e-06 0 1.29005e-06 0 1.294e-06 0 1.2941e-06 1 1.2945e-06 1 1.29455e-06 0 1.296e-06 0 1.29605e-06 0 1.3e-06 0 1.3001e-06 1 1.3005e-06 1 1.30055e-06 0 1.302e-06 0 1.30205e-06 0 1.306e-06 0 1.3061e-06 1 1.3065e-06 1 1.30655e-06 0 1.308e-06 0 1.30805e-06 0 1.312e-06 0 1.3121e-06 1 1.3125e-06 1 1.31255e-06 0 1.314e-06 0 1.31405e-06 0 1.318e-06 0 1.3181e-06 1 1.3185e-06 1 1.31855e-06 0 1.32e-06 0 1.32005e-06 0 1.324e-06 0 1.3241e-06 1 1.3245e-06 1 1.32455e-06 0 1.326e-06 0 1.32605e-06 0 1.33e-06 0 1.3301e-06 1 1.3305e-06 1 1.33055e-06 0 1.332e-06 0 1.33205e-06 0 1.336e-06 0 1.3361e-06 1 1.3365e-06 1 1.33655e-06 0 1.338e-06 0 1.33805e-06 0 1.342e-06 0 1.3421e-06 1 1.3425e-06 1 1.34255e-06 0 1.344e-06 0 1.34405e-06 0 1.348e-06 0 1.3481e-06 1 1.3485e-06 1 1.34855e-06 0 1.35e-06 0 1.35005e-06 0 1.354e-06 0 1.3541e-06 1 1.3545e-06 1 1.35455e-06 0 1.356e-06 0 1.35605e-06 0 1.36e-06 0 1.3601e-06 1 1.3605e-06 1 1.36055e-06 0 1.362e-06 0 1.36205e-06 0 1.366e-06 0 1.3661e-06 1 1.3665e-06 1 1.36655e-06 0 1.368e-06 0 1.36805e-06 0 1.372e-06 0 1.3721e-06 1 1.3725e-06 1 1.37255e-06 0 1.374e-06 0 1.37405e-06 0 1.378e-06 0 1.3781e-06 1 1.3785e-06 1 1.37855e-06 0 1.38e-06 0 1.38005e-06 0 1.384e-06 0 1.3841e-06 1 1.3845e-06 1 1.38455e-06 0 1.386e-06 0 1.38605e-06 0 1.39e-06 0 1.3901e-06 1 1.3905e-06 1 1.39055e-06 0 1.392e-06 0 1.39205e-06 0 1.396e-06 0 1.3961e-06 1 1.3965e-06 1 1.39655e-06 0 1.398e-06 0 1.39805e-06 0 1.402e-06 0 1.4021e-06 1 1.4025e-06 1 1.40255e-06 0 1.404e-06 0 1.40405e-06 0 1.408e-06 0 1.4081e-06 1 1.4085e-06 1 1.40855e-06 0 1.41e-06 0 1.41005e-06 0 1.414e-06 0 1.4141e-06 1 1.4145e-06 1 1.41455e-06 0 1.416e-06 0 1.41605e-06 0 1.42e-06 0 1.4201e-06 1 1.4205e-06 1 1.42055e-06 0 1.422e-06 0 1.42205e-06 0 1.426e-06 0 1.4261e-06 1 1.4265e-06 1 1.42655e-06 0 1.428e-06 0 1.42805e-06 0 1.432e-06 0 1.4321e-06 1 1.4325e-06 1 1.43255e-06 0 1.434e-06 0 1.43405e-06 0 1.438e-06 0 1.4381e-06 1 1.4385e-06 1 1.43855e-06 0 1.44e-06 0 1.44005e-06 0 1.444e-06 0 1.4441e-06 1 1.4445e-06 1 1.44455e-06 0 1.446e-06 0 1.44605e-06 0 1.45e-06 0 1.4501e-06 1 1.4505e-06 1 1.45055e-06 0 1.452e-06 0 1.45205e-06 0 1.456e-06 0 1.4561e-06 1 1.4565e-06 1 1.45655e-06 0 1.458e-06 0 1.45805e-06 0 1.462e-06 0 1.4621e-06 1 1.4625e-06 1 1.46255e-06 0 1.464e-06 0 1.46405e-06 0 1.468e-06 0 1.4681e-06 1 1.4685e-06 1 1.46855e-06 0 1.47e-06 0 1.47005e-06 0 1.474e-06 0 1.4741e-06 1 1.4745e-06 1 1.47455e-06 0 1.476e-06 0 1.47605e-06 0 1.48e-06 0 1.4801e-06 1 1.4805e-06 1 1.48055e-06 0 1.482e-06 0 1.48205e-06 0 1.486e-06 0 1.4861e-06 1 1.4865e-06 1 1.48655e-06 0 1.488e-06 0 1.48805e-06 0 1.492e-06 0 1.4921e-06 1 1.4925e-06 1 1.49255e-06 0 1.494e-06 0 1.49405e-06 0 1.498e-06 0 1.4981e-06 1 1.4985e-06 1 1.49855e-06 0 1.5e-06 0 1.50005e-06 0 1.504e-06 0 1.5041e-06 1 1.5045e-06 1 1.50455e-06 0 1.506e-06 0 1.50605e-06 0 1.51e-06 0 1.5101e-06 1 1.5105e-06 1 1.51055e-06 0 1.512e-06 0 1.51205e-06 0 1.516e-06 0 1.5161e-06 1 1.5165e-06 1 1.51655e-06 0 1.518e-06 0 1.51805e-06 0 1.522e-06 0 1.5221e-06 1 1.5225e-06 1 1.52255e-06 0 1.524e-06 0 1.52405e-06 0 1.528e-06 0 1.5281e-06 1 1.5285e-06 1 1.52855e-06 0 1.53e-06 0 1.53005e-06 0 1.534e-06 0 1.5341e-06 1 1.5345e-06 1 1.53455e-06 0 1.536e-06 0 1.53605e-06 0 1.54e-06 0 1.5401e-06 1 1.5405e-06 1 1.54055e-06 0 1.542e-06 0 1.54205e-06 0 1.546e-06 0 1.5461e-06 1 1.5465e-06 1 1.54655e-06 0 1.548e-06 0 1.54805e-06 0 1.552e-06 0 1.5521e-06 1 1.5525e-06 1 1.55255e-06 0 1.554e-06 0 1.55405e-06 0 1.558e-06 0 1.5581e-06 1 1.5585e-06 1 1.55855e-06 0 1.56e-06 0 1.56005e-06 0 1.564e-06 0 1.5641e-06 1 1.5645e-06 1 1.56455e-06 0 1.566e-06 0 1.56605e-06 0 1.57e-06 0 1.5701e-06 1 1.5705e-06 1 1.57055e-06 0 1.572e-06 0 1.57205e-06 0 1.576e-06 0 1.5761e-06 1 1.5765e-06 1 1.57655e-06 0 1.578e-06 0 1.57805e-06 0 1.582e-06 0 1.5821e-06 1 1.5825e-06 1 1.58255e-06 0 1.584e-06 0 1.58405e-06 0 1.588e-06 0 1.5881e-06 1 1.5885e-06 1 1.58855e-06 0 1.59e-06 0 1.59005e-06 0 1.594e-06 0 1.5941e-06 1 1.5945e-06 1 1.59455e-06 0 1.596e-06 0 1.59605e-06 0 1.6e-06 0 1.6001e-06 1 1.6005e-06 1 1.60055e-06 0 1.602e-06 0 1.60205e-06 0 1.606e-06 0 1.6061e-06 1 1.6065e-06 1 1.60655e-06 0 1.608e-06 0 1.60805e-06 0 1.612e-06 0 1.6121e-06 1 1.6125e-06 1 1.61255e-06 0 1.614e-06 0 1.61405e-06 0 1.618e-06 0 1.6181e-06 1 1.6185e-06 1 1.61855e-06 0 1.62e-06 0 1.62005e-06 0 1.624e-06 0 1.6241e-06 1 1.6245e-06 1 1.62455e-06 0 1.626e-06 0 1.62605e-06 0 1.63e-06 0 1.6301e-06 1 1.6305e-06 1 1.63055e-06 0 1.632e-06 0 1.63205e-06 0 1.636e-06 0 1.6361e-06 1 1.6365e-06 1 1.63655e-06 0 1.638e-06 0 1.63805e-06 0 1.642e-06 0 1.6421e-06 1 1.64250000000001e-06 1 1.64255e-06 0 1.644e-06 0 1.64405e-06 0 1.64800000000001e-06 0 1.64810000000001e-06 1 1.64850000000001e-06 1 1.64855e-06 0 1.65e-06 0 1.65005e-06 0 1.65400000000001e-06 0 1.65410000000001e-06 1 1.65450000000001e-06 1 1.65455e-06 0 1.656e-06 0 1.65605e-06 0 1.66000000000001e-06 0 1.66010000000001e-06 1 1.66050000000001e-06 1 1.66055000000001e-06 0 1.66200000000001e-06 0 1.66205e-06 0 1.66600000000001e-06 0 1.66610000000001e-06 1 1.66650000000001e-06 1 1.66655000000001e-06 0 1.66800000000001e-06 0 1.66805e-06 0 1.67200000000001e-06 0 1.67210000000001e-06 1 1.67250000000001e-06 1 1.67255000000001e-06 0 1.67400000000001e-06 0 1.67405e-06 0 1.67800000000001e-06 0 1.67810000000001e-06 1 1.67850000000001e-06 1 1.67855000000001e-06 0 1.68000000000001e-06 0 1.68005e-06 0 1.68400000000001e-06 0 1.68410000000001e-06 1 1.68450000000001e-06 1 1.68455000000001e-06 0 1.68600000000001e-06 0 1.68605000000001e-06 0 1.69000000000001e-06 0 1.69010000000001e-06 1 1.69050000000001e-06 1 1.69055000000001e-06 0 1.69200000000001e-06 0 1.69205000000001e-06 0 1.69600000000001e-06 0 1.69610000000001e-06 1 1.69650000000001e-06 1 1.69655000000001e-06 0 1.69800000000001e-06 0 1.69805000000001e-06 0 1.70200000000001e-06 0 1.70210000000001e-06 1 1.70250000000001e-06 1 1.70255000000001e-06 0 1.70400000000001e-06 0 1.70405000000001e-06 0 1.70800000000001e-06 0 1.70810000000001e-06 1 1.70850000000001e-06 1 1.70855000000001e-06 0 1.71000000000001e-06 0 1.71005000000001e-06 0 1.71400000000001e-06 0 1.71410000000001e-06 1 1.71450000000001e-06 1 1.71455000000001e-06 0 1.71600000000001e-06 0 1.71605000000001e-06 0 1.72000000000001e-06 0 1.72010000000001e-06 1 1.72050000000001e-06 1 1.72055000000001e-06 0 1.72200000000001e-06 0 1.72205000000001e-06 0 1.72600000000001e-06 0 1.72610000000001e-06 1 1.72650000000001e-06 1 1.72655000000001e-06 0 1.72800000000001e-06 0 1.72805000000001e-06 0 1.73200000000001e-06 0 1.73210000000001e-06 1 1.73250000000001e-06 1 1.73255000000001e-06 0 1.73400000000001e-06 0 1.73405000000001e-06 0 1.73800000000001e-06 0 1.73810000000001e-06 1 1.73850000000001e-06 1 1.73855000000001e-06 0 1.74000000000001e-06 0 1.74005000000001e-06 0 1.74400000000001e-06 0 1.74410000000001e-06 1 1.74450000000001e-06 1 1.74455000000001e-06 0 1.74600000000001e-06 0 1.74605000000001e-06 0 1.75000000000001e-06 0 1.75010000000001e-06 1 1.75050000000001e-06 1 1.75055000000001e-06 0 1.75200000000001e-06 0 1.75205000000001e-06 0 1.75600000000001e-06 0 1.75610000000001e-06 1 1.75650000000001e-06 1 1.75655000000001e-06 0 1.75800000000001e-06 0 1.75805000000001e-06 0 1.76200000000001e-06 0 1.76210000000001e-06 1 1.76250000000001e-06 1 1.76255000000001e-06 0 1.76400000000001e-06 0 1.76405000000001e-06 0 1.76800000000001e-06 0 1.76810000000001e-06 1 1.76850000000001e-06 1 1.76855000000001e-06 0 1.77000000000001e-06 0 1.77005000000001e-06 0 1.77400000000001e-06 0 1.77410000000001e-06 1 1.77450000000001e-06 1 1.77455000000001e-06 0 1.77600000000001e-06 0 1.77605000000001e-06 0 1.78000000000001e-06 0 1.78010000000001e-06 1 1.78050000000001e-06 1 1.78055000000001e-06 0 1.78200000000001e-06 0 1.78205000000001e-06 0 1.78600000000001e-06 0 1.78610000000001e-06 1 1.78650000000001e-06 1 1.78655000000001e-06 0 1.78800000000001e-06 0 1.78805000000001e-06 0 1.79200000000001e-06 0 1.79210000000001e-06 1 1.79250000000001e-06 1 1.79255000000001e-06 0 1.79400000000001e-06 0 1.79405000000001e-06 0 1.79800000000001e-06 0 1.79810000000001e-06 1 1.79850000000001e-06 1 1.79855000000001e-06 0 1.80000000000001e-06 0 1.80005000000001e-06 0 1.80400000000001e-06 0 1.80410000000001e-06 1 1.80450000000001e-06 1 1.80455000000001e-06 0 1.80600000000001e-06 0 1.80605000000001e-06 0 1.81000000000001e-06 0 1.81010000000001e-06 1 1.81050000000001e-06 1 1.81055000000001e-06 0 1.81200000000001e-06 0 1.81205000000001e-06 0 1.81600000000001e-06 0 1.81610000000001e-06 1 1.81650000000001e-06 1 1.81655000000001e-06 0 1.81800000000001e-06 0 1.81805000000001e-06 0 1.82200000000001e-06 0 1.82210000000001e-06 1 1.82250000000001e-06 1 1.82255000000001e-06 0 1.82400000000001e-06 0 1.82405000000001e-06 0 1.82800000000001e-06 0 1.82810000000001e-06 1 1.82850000000001e-06 1 1.82855000000001e-06 0 1.83000000000001e-06 0 1.83005000000001e-06 0 1.83400000000001e-06 0 1.83410000000001e-06 1 1.83450000000001e-06 1 1.83455000000001e-06 0 1.83600000000001e-06 0 1.83605000000001e-06 0 1.84000000000001e-06 0 1.84010000000001e-06 1 1.84050000000001e-06 1 1.84055000000001e-06 0 1.84200000000001e-06 0 1.84205000000001e-06 0 1.84600000000001e-06 0 1.84610000000001e-06 1 1.84650000000001e-06 1 1.84655000000001e-06 0 1.84800000000001e-06 0 1.84805000000001e-06 0 1.85200000000001e-06 0 1.85210000000001e-06 1 1.85250000000001e-06 1 1.85255000000001e-06 0 1.85400000000001e-06 0 1.85405000000001e-06 0 1.85800000000001e-06 0 1.85810000000001e-06 1 1.85850000000001e-06 1 1.85855000000001e-06 0 1.86000000000001e-06 0 1.86005000000001e-06 0 1.86400000000001e-06 0 1.86410000000001e-06 1 1.86450000000001e-06 1 1.86455000000001e-06 0 1.86600000000001e-06 0 1.86605000000001e-06 0 1.87000000000001e-06 0 1.87010000000001e-06 1 1.87050000000001e-06 1 1.87055000000001e-06 0 1.87200000000001e-06 0 1.87205000000001e-06 0 1.87600000000001e-06 0 1.87610000000001e-06 1 1.87650000000001e-06 1 1.87655000000001e-06 0 1.87800000000001e-06 0 1.87805000000001e-06 0 1.88200000000001e-06 0 1.88210000000001e-06 1 1.88250000000001e-06 1 1.88255000000001e-06 0 1.88400000000001e-06 0 1.88405000000001e-06 0 1.88800000000001e-06 0 1.88810000000001e-06 1 1.88850000000001e-06 1 1.88855000000001e-06 0 1.89000000000001e-06 0 1.89005000000001e-06 0 1.89400000000001e-06 0 1.89410000000001e-06 1 1.89450000000001e-06 1 1.89455000000001e-06 0 1.89600000000001e-06 0 1.89605000000001e-06 0 1.90000000000001e-06 0 1.90010000000001e-06 1 1.90050000000001e-06 1 1.90055000000001e-06 0 1.90200000000001e-06 0 1.90205000000001e-06 0 1.90600000000001e-06 0 1.90610000000001e-06 1 1.90650000000001e-06 1 1.90655000000001e-06 0 1.90800000000001e-06 0 1.90805000000001e-06 0 1.91200000000001e-06 0 1.91210000000001e-06 1 1.91250000000001e-06 1 1.91255000000001e-06 0 1.91400000000001e-06 0 1.91405000000001e-06 0 1.91800000000001e-06 0 1.91810000000001e-06 1 1.91850000000001e-06 1 1.91855000000001e-06 0 1.92000000000001e-06 0 1.92005000000001e-06 0 1.92400000000001e-06 0 1.92410000000001e-06 1 1.92450000000001e-06 1 1.92455000000001e-06 0 1.926e-06 0 1.92605000000001e-06 0 1.93e-06 0 1.9301e-06 1 1.9305e-06 1 1.93055e-06 0 1.932e-06 0 1.93205e-06 0 1.936e-06 0 1.9361e-06 1 1.9365e-06 1 1.93655e-06 0 1.938e-06 0 1.93805e-06 0 1.942e-06 0 1.9421e-06 1 1.9425e-06 1 1.94255e-06 0 1.944e-06 0 1.94405e-06 0 1.948e-06 0 1.9481e-06 1 1.9485e-06 1 1.94855e-06 0 1.95e-06 0 1.95005e-06 0 1.954e-06 0 1.9541e-06 1 1.9545e-06 1 1.95455e-06 0 1.956e-06 0 1.95605e-06 0 1.96e-06 0 1.9601e-06 1 1.9605e-06 1 1.96055e-06 0 1.962e-06 0 1.96205e-06 0 1.966e-06 0 1.9661e-06 1 1.9665e-06 1 1.96655e-06 0 1.968e-06 0 1.96805e-06 0 1.972e-06 0 1.9721e-06 1 1.9725e-06 1 1.97255e-06 0 1.974e-06 0 1.97405e-06 0 1.978e-06 0 1.9781e-06 1 1.9785e-06 1 1.97855e-06 0 1.98e-06 0 1.98005e-06 0 1.984e-06 0 1.9841e-06 1 1.9845e-06 1 1.98455e-06 0 1.986e-06 0 1.98605e-06 0 1.99e-06 0 1.9901e-06 1 1.9905e-06 1 1.99055e-06 0 1.992e-06 0 1.99205e-06 0 1.996e-06 0 1.9961e-06 1 1.9965e-06 1 1.99655e-06 0 1.998e-06 0 1.99805e-06 0 2.002e-06 0 2.0021e-06 1 2.0025e-06 1 2.00255e-06 0 2.004e-06 0 2.00405e-06 0 2.008e-06 0 2.0081e-06 1 2.0085e-06 1 2.00855e-06 0 2.01e-06 0 2.01005e-06 0 2.014e-06 0 2.0141e-06 1 2.0145e-06 1 2.01455e-06 0 2.016e-06 0 2.01605e-06 0 2.02e-06 0 2.0201e-06 1 2.0205e-06 1 2.02055e-06 0 2.022e-06 0 2.02205e-06 0 2.026e-06 0 2.0261e-06 1 2.0265e-06 1 2.02655e-06 0 2.028e-06 0 2.02805e-06 0 2.032e-06 0 2.0321e-06 1 2.0325e-06 1 2.03255e-06 0 2.034e-06 0 2.03405e-06 0 2.038e-06 0 2.0381e-06 1 2.0385e-06 1 2.03855e-06 0 2.04e-06 0 2.04005e-06 0 2.044e-06 0 2.0441e-06 1 2.0445e-06 1 2.04455e-06 0 2.046e-06 0 2.04605e-06 0 2.05e-06 0 2.0501e-06 1 2.0505e-06 1 2.05055e-06 0 2.052e-06 0 2.05205e-06 0 2.056e-06 0 2.0561e-06 1 2.0565e-06 1 2.05655e-06 0 2.058e-06 0 2.05805e-06 0 2.062e-06 0 2.0621e-06 1 2.0625e-06 1 2.06255e-06 0 2.064e-06 0 2.06405e-06 0 2.068e-06 0 2.0681e-06 1 2.0685e-06 1 2.06855e-06 0 2.07e-06 0 2.07005e-06 0 2.074e-06 0 2.0741e-06 1 2.0745e-06 1 2.07455e-06 0 2.076e-06 0 2.07605e-06 0 2.07999999999999e-06 0 2.08009999999999e-06 1 2.08049999999999e-06 1 2.08054999999999e-06 0 2.08199999999999e-06 0 2.08204999999999e-06 0 2.08599999999999e-06 0 2.08609999999999e-06 1 2.08649999999999e-06 1 2.08654999999999e-06 0 2.08799999999999e-06 0 2.08804999999999e-06 0 2.09199999999999e-06 0 2.09209999999999e-06 1 2.09249999999999e-06 1 2.09254999999999e-06 0 2.09399999999999e-06 0 2.09404999999999e-06 0 2.09799999999999e-06 0 2.09809999999999e-06 1 2.09849999999999e-06 1 2.09854999999999e-06 0 2.09999999999999e-06 0 2.10004999999999e-06 0 2.10399999999999e-06 0 2.10409999999999e-06 1 2.10449999999999e-06 1 2.10454999999999e-06 0 2.10599999999999e-06 0 2.10604999999999e-06 0 2.10999999999999e-06 0 2.11009999999999e-06 1 2.11049999999999e-06 1 2.11054999999999e-06 0 2.11199999999999e-06 0 2.11204999999999e-06 0 2.11599999999999e-06 0 2.11609999999999e-06 1 2.11649999999999e-06 1 2.11654999999999e-06 0 2.11799999999999e-06 0 2.11804999999999e-06 0 2.12199999999999e-06 0 2.12209999999999e-06 1 2.12249999999999e-06 1 2.12254999999999e-06 0 2.12399999999999e-06 0 2.12404999999999e-06 0 2.12799999999999e-06 0 2.12809999999999e-06 1 2.12849999999999e-06 1 2.12854999999999e-06 0 2.12999999999999e-06 0 2.13004999999999e-06 0 2.13399999999999e-06 0 2.13409999999999e-06 1 2.13449999999999e-06 1 2.13454999999999e-06 0 2.13599999999999e-06 0 2.13604999999999e-06 0 2.13999999999999e-06 0 2.14009999999999e-06 1 2.14049999999999e-06 1 2.14054999999999e-06 0 2.14199999999999e-06 0 2.14204999999999e-06 0 2.14599999999999e-06 0 2.14609999999999e-06 1 2.14649999999999e-06 1 2.14654999999999e-06 0 2.14799999999999e-06 0 2.14804999999999e-06 0 2.15199999999999e-06 0 2.15209999999999e-06 1 2.15249999999999e-06 1 2.15254999999999e-06 0 2.15399999999999e-06 0 2.15404999999999e-06 0 2.15799999999999e-06 0 2.15809999999999e-06 1 2.15849999999999e-06 1 2.15854999999999e-06 0 2.15999999999999e-06 0 2.16004999999999e-06 0 2.16399999999999e-06 0 2.16409999999999e-06 1 2.16449999999999e-06 1 2.16454999999999e-06 0 2.16599999999999e-06 0 2.16604999999999e-06 0 2.16999999999999e-06 0 2.17009999999999e-06 1 2.17049999999999e-06 1 2.17054999999999e-06 0 2.17199999999999e-06 0 2.17204999999999e-06 0 2.17599999999999e-06 0 2.17609999999999e-06 1 2.17649999999999e-06 1 2.17654999999999e-06 0 2.17799999999999e-06 0 2.17804999999999e-06 0 2.18199999999999e-06 0 2.18209999999999e-06 1 2.18249999999999e-06 1 2.18254999999999e-06 0 2.18399999999999e-06 0 2.18404999999999e-06 0 2.18799999999999e-06 0 2.18809999999999e-06 1 2.18849999999999e-06 1 2.18854999999999e-06 0 2.18999999999999e-06 0 2.19004999999999e-06 0 2.19399999999999e-06 0 2.19409999999999e-06 1 2.19449999999999e-06 1 2.19454999999999e-06 0 2.19599999999999e-06 0 2.19604999999999e-06 0 2.19999999999999e-06 0 2.20009999999999e-06 1 2.20049999999999e-06 1 2.20054999999999e-06 0 2.20199999999999e-06 0 2.20204999999999e-06 0 2.20599999999999e-06 0 2.20609999999999e-06 1 2.20649999999999e-06 1 2.20654999999999e-06 0 2.20799999999999e-06 0 2.20804999999999e-06 0 2.21199999999999e-06 0 2.21209999999999e-06 1 2.21249999999999e-06 1 2.21254999999999e-06 0 2.21399999999999e-06 0 2.21404999999999e-06 0 2.21799999999999e-06 0 2.21809999999999e-06 1 2.21849999999999e-06 1 2.21854999999999e-06 0 2.21999999999999e-06 0 2.22004999999999e-06 0 2.22399999999999e-06 0 2.22409999999999e-06 1 2.22449999999999e-06 1 2.22454999999999e-06 0 2.22599999999999e-06 0 2.22604999999999e-06 0 2.22999999999999e-06 0 2.23009999999998e-06 1 2.23049999999998e-06 1 2.23054999999998e-06 0 2.23199999999998e-06 0 2.23204999999998e-06 0 2.23599999999998e-06 0 2.23609999999998e-06 1 2.23649999999998e-06 1 2.23654999999998e-06 0 2.23799999999998e-06 0 2.23804999999998e-06 0 2.24199999999998e-06 0 2.24209999999998e-06 1 2.24249999999998e-06 1 2.24254999999998e-06 0 2.24399999999998e-06 0 2.24404999999998e-06 0 2.24799999999998e-06 0 2.24809999999998e-06 1 2.24849999999998e-06 1 2.24854999999998e-06 0 2.24999999999998e-06 0 2.25004999999998e-06 0 2.25399999999998e-06 0 2.25409999999998e-06 1 2.25449999999998e-06 1 2.25454999999998e-06 0 2.25599999999998e-06 0 2.25604999999998e-06 0 2.25999999999998e-06 0 2.26009999999998e-06 1 2.26049999999998e-06 1 2.26054999999998e-06 0 2.26199999999998e-06 0 2.26204999999998e-06 0 2.26599999999998e-06 0 2.26609999999998e-06 1 2.26649999999998e-06 1 2.26654999999998e-06 0 2.26799999999998e-06 0 2.26804999999998e-06 0 2.27199999999998e-06 0 2.27209999999998e-06 1 2.27249999999998e-06 1 2.27254999999998e-06 0 2.27399999999998e-06 0 2.27404999999998e-06 0 2.27799999999998e-06 0 2.27809999999998e-06 1 2.27849999999998e-06 1 2.27854999999998e-06 0 2.27999999999998e-06 0 2.28004999999998e-06 0 2.28399999999998e-06 0 2.28409999999998e-06 1 2.28449999999998e-06 1 2.28454999999998e-06 0 2.28599999999998e-06 0 2.28604999999998e-06 0 2.28999999999998e-06 0 2.29009999999998e-06 1 2.29049999999998e-06 1 2.29054999999998e-06 0 2.29199999999998e-06 0 2.29204999999998e-06 0 2.29599999999998e-06 0 2.29609999999998e-06 1 2.29649999999998e-06 1 2.29654999999998e-06 0 2.29799999999998e-06 0 2.29804999999998e-06 0 2.30199999999998e-06 0 2.30209999999998e-06 1 2.30249999999998e-06 1 2.30254999999998e-06 0 2.30399999999998e-06 0 2.30404999999998e-06 0 2.30799999999998e-06 0 2.30809999999998e-06 1 2.30849999999998e-06 1 2.30854999999998e-06 0 2.30999999999998e-06 0 2.31004999999998e-06 0 2.31399999999998e-06 0 2.31409999999998e-06 1 2.31449999999998e-06 1 2.31454999999998e-06 0 2.31599999999998e-06 0 2.31604999999998e-06 0 2.31999999999998e-06 0 2.32009999999998e-06 1 2.32049999999998e-06 1 2.32054999999998e-06 0 2.32199999999998e-06 0 2.32204999999998e-06 0 2.32599999999998e-06 0 2.32609999999998e-06 1 2.32649999999998e-06 1 2.32654999999998e-06 0 2.32799999999998e-06 0 2.32804999999998e-06 0 2.33199999999998e-06 0 2.33209999999998e-06 1 2.33249999999998e-06 1 2.33254999999998e-06 0 2.33399999999998e-06 0 2.33404999999998e-06 0 2.33799999999998e-06 0 2.33809999999998e-06 1 2.33849999999998e-06 1 2.33854999999998e-06 0 2.33999999999998e-06 0 2.34004999999998e-06 0 2.34399999999998e-06 0 2.34409999999998e-06 1 2.34449999999998e-06 1 2.34454999999998e-06 0 2.34599999999998e-06 0 2.34604999999998e-06 0 2.34999999999998e-06 0 2.35009999999998e-06 1 2.35049999999998e-06 1 2.35054999999998e-06 0 2.35199999999998e-06 0 2.35204999999998e-06 0 2.35599999999998e-06 0 2.35609999999998e-06 1 2.35649999999998e-06 1 2.35654999999998e-06 0 2.35799999999998e-06 0 2.35804999999998e-06 0 2.36199999999998e-06 0 2.36209999999998e-06 1 2.36249999999998e-06 1 2.36254999999998e-06 0 2.36399999999998e-06 0 2.36404999999998e-06 0 2.36799999999998e-06 0 2.36809999999998e-06 1 2.36849999999998e-06 1 2.36854999999998e-06 0 2.36999999999998e-06 0 2.37004999999998e-06 0 2.37399999999998e-06 0 2.37409999999998e-06 1 2.37449999999998e-06 1 2.37454999999998e-06 0 2.37599999999998e-06 0 2.37604999999998e-06 0 2.37999999999998e-06 0 2.38009999999997e-06 1 2.38049999999997e-06 1 2.38054999999998e-06 0 2.38199999999997e-06 0 2.38204999999997e-06 0 2.38599999999997e-06 0 2.38609999999997e-06 1 2.38649999999997e-06 1 2.38654999999997e-06 0 2.38799999999997e-06 0 2.38804999999997e-06 0 2.39199999999997e-06 0 2.39209999999997e-06 1 2.39249999999997e-06 1 2.39254999999997e-06 0 2.39399999999997e-06 0 2.39404999999997e-06 0 2.39799999999997e-06 0 2.39809999999997e-06 1 2.39849999999997e-06 1 2.39854999999997e-06 0 2.39999999999997e-06 0 2.40004999999997e-06 0 2.40399999999997e-06 0 2.40409999999997e-06 1 2.40449999999997e-06 1 2.40454999999997e-06 0 2.40599999999997e-06 0 2.40604999999997e-06 0 2.40999999999997e-06 0 2.41009999999997e-06 1 2.41049999999997e-06 1 2.41054999999997e-06 0 2.41199999999997e-06 0 2.41204999999997e-06 0 2.41599999999997e-06 0 2.41609999999997e-06 1 2.41649999999997e-06 1 2.41654999999997e-06 0 2.41799999999997e-06 0 2.41804999999997e-06 0 2.42199999999997e-06 0 2.42209999999997e-06 1 2.42249999999997e-06 1 2.42254999999997e-06 0 2.42399999999997e-06 0 2.42404999999997e-06 0 2.42799999999997e-06 0 2.42809999999997e-06 1 2.42849999999997e-06 1 2.42854999999997e-06 0 2.42999999999997e-06 0 2.43004999999997e-06 0 2.43399999999997e-06 0 2.43409999999997e-06 1 2.43449999999997e-06 1 2.43454999999997e-06 0 2.43599999999997e-06 0 2.43604999999997e-06 0 2.43999999999997e-06 0 2.44009999999997e-06 1 2.44049999999997e-06 1 2.44054999999997e-06 0 2.44199999999997e-06 0 2.44204999999997e-06 0 2.44599999999997e-06 0 2.44609999999997e-06 1 2.44649999999997e-06 1 2.44654999999997e-06 0 2.44799999999997e-06 0 2.44804999999997e-06 0 2.45199999999997e-06 0 2.45209999999997e-06 1 2.45249999999997e-06 1 2.45254999999997e-06 0 2.45399999999997e-06 0 2.45404999999997e-06 0 2.45799999999997e-06 0 2.45809999999997e-06 1 2.45849999999997e-06 1 2.45854999999997e-06 0 2.45999999999997e-06 0 2.46004999999997e-06 0 2.46399999999997e-06 0 2.46409999999997e-06 1 2.46449999999997e-06 1 2.46454999999997e-06 0 2.46599999999997e-06 0 2.46604999999997e-06 0 2.46999999999997e-06 0 2.47009999999997e-06 1 2.47049999999997e-06 1 2.47054999999997e-06 0 2.47199999999997e-06 0 2.47204999999997e-06 0 2.47599999999997e-06 0 2.47609999999997e-06 1 2.47649999999997e-06 1 2.47654999999997e-06 0 2.47799999999997e-06 0 2.47804999999997e-06 0 2.48199999999997e-06 0 2.48209999999997e-06 1 2.48249999999997e-06 1 2.48254999999997e-06 0 2.48399999999997e-06 0 2.48404999999997e-06 0 2.48799999999997e-06 0 2.48809999999997e-06 1 2.48849999999997e-06 1 2.48854999999997e-06 0 2.48999999999997e-06 0 2.49004999999997e-06 0 2.49399999999997e-06 0 2.49409999999997e-06 1 2.49449999999997e-06 1 2.49454999999997e-06 0 2.49599999999997e-06 0 2.49604999999997e-06 0 2.49999999999997e-06 0 2.50009999999997e-06 1 2.50049999999997e-06 1 2.50054999999997e-06 0 2.50199999999997e-06 0 2.50204999999997e-06 0 2.50599999999997e-06 0 2.50609999999997e-06 1 2.50649999999997e-06 1 2.50654999999997e-06 0 2.50799999999997e-06 0 2.50804999999997e-06 0 2.51199999999997e-06 0 2.51209999999997e-06 1 2.51249999999997e-06 1 2.51254999999997e-06 0 2.51399999999997e-06 0 2.51404999999997e-06 0 2.51799999999997e-06 0 2.51809999999997e-06 1 2.51849999999997e-06 1 2.51854999999997e-06 0 2.51999999999997e-06 0 2.52004999999997e-06 0 2.52399999999997e-06 0 2.52409999999997e-06 1 2.52449999999997e-06 1 2.52454999999997e-06 0 2.52599999999997e-06 0 2.52604999999997e-06 0 2.52999999999997e-06 0 2.53009999999996e-06 1 2.53049999999997e-06 1 2.53054999999997e-06 0 2.53199999999996e-06 0 2.53204999999997e-06 0 2.53599999999996e-06 0 2.53609999999996e-06 1 2.53649999999996e-06 1 2.53654999999996e-06 0 2.53799999999996e-06 0 2.53804999999996e-06 0 2.54199999999996e-06 0 2.54209999999996e-06 1 2.54249999999996e-06 1 2.54254999999996e-06 0 2.54399999999996e-06 0 2.54404999999996e-06 0 2.54799999999996e-06 0 2.54809999999996e-06 1 2.54849999999996e-06 1 2.54854999999996e-06 0 2.54999999999996e-06 0 2.55004999999996e-06 0 2.55399999999996e-06 0 2.55409999999996e-06 1 2.55449999999996e-06 1 2.55454999999996e-06 0 2.55599999999996e-06 0 2.55604999999996e-06 0 2.55999999999996e-06 0 2.56009999999996e-06 1 2.56049999999996e-06 1 2.56054999999996e-06 0 2.56199999999996e-06 0 2.56204999999996e-06 0 2.56599999999996e-06 0 2.56609999999996e-06 1 2.56649999999996e-06 1 2.56654999999996e-06 0 2.56799999999996e-06 0 2.56804999999996e-06 0 2.57199999999996e-06 0 2.57209999999996e-06 1 2.57249999999996e-06 1 2.57254999999996e-06 0 2.57399999999996e-06 0 2.57404999999996e-06 0 2.57799999999996e-06 0 2.57809999999996e-06 1 2.57849999999996e-06 1 2.57854999999996e-06 0 2.57999999999996e-06 0 2.58004999999996e-06 0 2.58399999999996e-06 0 2.58409999999996e-06 1 2.58449999999996e-06 1 2.58454999999996e-06 0 2.58599999999996e-06 0 2.58604999999996e-06 0 2.58999999999996e-06 0 2.59009999999996e-06 1 2.59049999999996e-06 1 2.59054999999996e-06 0 2.59199999999996e-06 0 2.59204999999996e-06 0 2.59599999999996e-06 0 2.59609999999996e-06 1 2.59649999999996e-06 1 2.59654999999996e-06 0 2.59799999999996e-06 0 2.59804999999996e-06 0 2.60199999999996e-06 0 2.60209999999996e-06 1 2.60249999999996e-06 1 2.60254999999996e-06 0 2.60399999999996e-06 0 2.60404999999996e-06 0 2.60799999999996e-06 0 2.60809999999996e-06 1 2.60849999999996e-06 1 2.60854999999996e-06 0 2.60999999999996e-06 0 2.61004999999996e-06 0 2.61399999999996e-06 0 2.61409999999996e-06 1 2.61449999999996e-06 1 2.61454999999996e-06 0 2.61599999999996e-06 0 2.61604999999996e-06 0 2.61999999999996e-06 0 2.62009999999996e-06 1 2.62049999999996e-06 1 2.62054999999996e-06 0 2.62199999999996e-06 0 2.62204999999996e-06 0 2.62599999999996e-06 0 2.62609999999996e-06 1 2.62649999999996e-06 1 2.62654999999996e-06 0 2.62799999999996e-06 0 2.62804999999996e-06 0 2.63199999999996e-06 0 2.63209999999996e-06 1 2.63249999999996e-06 1 2.63254999999996e-06 0 2.63399999999996e-06 0 2.63404999999996e-06 0 2.63799999999996e-06 0 2.63809999999996e-06 1 2.63849999999996e-06 1 2.63854999999996e-06 0 2.63999999999996e-06 0 2.64004999999996e-06 0 2.64399999999996e-06 0 2.64409999999996e-06 1 2.64449999999996e-06 1 2.64454999999996e-06 0 2.64599999999996e-06 0 2.64604999999996e-06 0 2.64999999999996e-06 0 2.65009999999996e-06 1 2.65049999999996e-06 1 2.65054999999996e-06 0 2.65199999999996e-06 0 2.65204999999996e-06 0 2.65599999999996e-06 0 2.65609999999996e-06 1 2.65649999999996e-06 1 2.65654999999996e-06 0 2.65799999999996e-06 0 2.65804999999996e-06 0 2.66199999999996e-06 0 2.66209999999996e-06 1 2.66249999999996e-06 1 2.66254999999996e-06 0 2.66399999999996e-06 0 2.66404999999996e-06 0 2.66799999999996e-06 0 2.66809999999996e-06 1 2.66849999999996e-06 1 2.66854999999996e-06 0 2.66999999999996e-06 0 2.67004999999996e-06 0 2.67399999999996e-06 0 2.67409999999996e-06 1 2.67449999999996e-06 1 2.67454999999996e-06 0 2.67599999999996e-06 0 2.67604999999996e-06 0 2.67999999999996e-06 0 2.68009999999996e-06 1 2.68049999999996e-06 1 2.68054999999996e-06 0 2.68199999999996e-06 0 2.68204999999996e-06 0 2.68599999999995e-06 0 2.68609999999995e-06 1 2.68649999999995e-06 1 2.68654999999995e-06 0 2.68799999999995e-06 0 2.68804999999995e-06 0 2.69199999999995e-06 0 2.69209999999995e-06 1 2.69249999999995e-06 1 2.69254999999995e-06 0 2.69399999999995e-06 0 2.69404999999995e-06 0 2.69799999999995e-06 0 2.69809999999995e-06 1 2.69849999999995e-06 1 2.69854999999995e-06 0 2.69999999999995e-06 0 2.70004999999995e-06 0 2.70399999999995e-06 0 2.70409999999995e-06 1 2.70449999999995e-06 1 2.70454999999995e-06 0 2.70599999999995e-06 0 2.70604999999995e-06 0 2.70999999999995e-06 0 2.71009999999995e-06 1 2.71049999999995e-06 1 2.71054999999995e-06 0 2.71199999999995e-06 0 2.71204999999995e-06 0 2.71599999999995e-06 0 2.71609999999995e-06 1 2.71649999999995e-06 1 2.71654999999995e-06 0 2.71799999999995e-06 0 2.71804999999995e-06 0 2.72199999999995e-06 0 2.72209999999995e-06 1 2.72249999999995e-06 1 2.72254999999995e-06 0 2.72399999999995e-06 0 2.72404999999995e-06 0 2.72799999999995e-06 0 2.72809999999995e-06 1 2.72849999999995e-06 1 2.72854999999995e-06 0 2.72999999999995e-06 0 2.73004999999995e-06 0 2.73399999999995e-06 0 2.73409999999995e-06 1 2.73449999999995e-06 1 2.73454999999995e-06 0 2.73599999999995e-06 0 2.73604999999995e-06 0 2.73999999999995e-06 0 2.74009999999995e-06 1 2.74049999999995e-06 1 2.74054999999995e-06 0 2.74199999999995e-06 0 2.74204999999995e-06 0 2.74599999999995e-06 0 2.74609999999995e-06 1 2.74649999999995e-06 1 2.74654999999995e-06 0 2.74799999999995e-06 0 2.74804999999995e-06 0 2.75199999999995e-06 0 2.75209999999995e-06 1 2.75249999999995e-06 1 2.75254999999995e-06 0 2.75399999999995e-06 0 2.75404999999995e-06 0 2.75799999999995e-06 0 2.75809999999995e-06 1 2.75849999999995e-06 1 2.75854999999995e-06 0 2.75999999999995e-06 0 2.76004999999995e-06 0 2.76399999999995e-06 0 2.76409999999995e-06 1 2.76449999999995e-06 1 2.76454999999995e-06 0 2.76599999999995e-06 0 2.76604999999995e-06 0 2.76999999999995e-06 0 2.77009999999995e-06 1 2.77049999999995e-06 1 2.77054999999995e-06 0 2.77199999999995e-06 0 2.77204999999995e-06 0 2.77599999999995e-06 0 2.77609999999995e-06 1 2.77649999999995e-06 1 2.77654999999995e-06 0 2.77799999999995e-06 0 2.77804999999995e-06 0 2.78199999999995e-06 0 2.78209999999995e-06 1 2.78249999999995e-06 1 2.78254999999995e-06 0 2.78399999999995e-06 0 2.78404999999995e-06 0 2.78799999999995e-06 0 2.78809999999995e-06 1 2.78849999999995e-06 1 2.78854999999995e-06 0 2.78999999999995e-06 0 2.79004999999995e-06 0 2.79399999999995e-06 0 2.79409999999995e-06 1 2.79449999999995e-06 1 2.79454999999995e-06 0 2.79599999999995e-06 0 2.79604999999995e-06 0 2.79999999999995e-06 0 2.80009999999995e-06 1 2.80049999999995e-06 1 2.80054999999995e-06 0 2.80199999999995e-06 0 2.80204999999995e-06 0 2.80599999999995e-06 0 2.80609999999995e-06 1 2.80649999999995e-06 1 2.80654999999995e-06 0 2.80799999999995e-06 0 2.80804999999995e-06 0 2.81199999999995e-06 0 2.81209999999995e-06 1 2.81249999999995e-06 1 2.81254999999995e-06 0 2.81399999999995e-06 0 2.81404999999995e-06 0 2.81799999999995e-06 0 2.81809999999995e-06 1 2.81849999999995e-06 1 2.81854999999995e-06 0 2.81999999999995e-06 0 2.82004999999995e-06 0 2.82399999999995e-06 0 2.82409999999995e-06 1 2.82449999999995e-06 1 2.82454999999995e-06 0 2.82599999999995e-06 0 2.82604999999995e-06 0 2.82999999999995e-06 0 2.83009999999995e-06 1 2.83049999999995e-06 1 2.83054999999995e-06 0 2.83199999999995e-06 0 2.83204999999995e-06 0 2.83599999999994e-06 0 2.83609999999994e-06 1 2.83649999999994e-06 1 2.83654999999994e-06 0 2.83799999999994e-06 0 2.83804999999994e-06 0 2.84199999999994e-06 0 2.84209999999994e-06 1 2.84249999999994e-06 1 2.84254999999994e-06 0 2.84399999999994e-06 0 2.84404999999994e-06 0 2.84799999999994e-06 0 2.84809999999994e-06 1 2.84849999999994e-06 1 2.84854999999994e-06 0 2.84999999999994e-06 0 2.85004999999994e-06 0 2.85399999999994e-06 0 2.85409999999994e-06 1 2.85449999999994e-06 1 2.85454999999994e-06 0 2.85599999999994e-06 0 2.85604999999994e-06 0 2.85999999999994e-06 0 2.86009999999994e-06 1 2.86049999999994e-06 1 2.86054999999994e-06 0 2.86199999999994e-06 0 2.86204999999994e-06 0 2.86599999999994e-06 0 2.86609999999994e-06 1 2.86649999999994e-06 1 2.86654999999994e-06 0 2.86799999999994e-06 0 2.86804999999994e-06 0 2.87199999999994e-06 0 2.87209999999994e-06 1 2.87249999999994e-06 1 2.87254999999994e-06 0 2.87399999999994e-06 0 2.87404999999994e-06 0 2.87799999999994e-06 0 2.87809999999994e-06 1 2.87849999999994e-06 1 2.87854999999994e-06 0 2.87999999999994e-06 0 2.88004999999994e-06 0 2.88399999999994e-06 0 2.88409999999994e-06 1 2.88449999999994e-06 1 2.88454999999994e-06 0 2.88599999999994e-06 0 2.88604999999994e-06 0 2.88999999999994e-06 0 2.89009999999994e-06 1 2.89049999999994e-06 1 2.89054999999994e-06 0 2.89199999999994e-06 0 2.89204999999994e-06 0 2.89599999999994e-06 0 2.89609999999994e-06 1 2.89649999999994e-06 1 2.89654999999994e-06 0 2.89799999999994e-06 0 2.89804999999994e-06 0 2.90199999999994e-06 0 2.90209999999994e-06 1 2.90249999999994e-06 1 2.90254999999994e-06 0 2.90399999999994e-06 0 2.90404999999994e-06 0 2.90799999999994e-06 0 2.90809999999994e-06 1 2.90849999999994e-06 1 2.90854999999994e-06 0 2.90999999999994e-06 0 2.91004999999994e-06 0 2.91399999999994e-06 0 2.91409999999994e-06 1 2.91449999999994e-06 1 2.91454999999994e-06 0 2.91599999999994e-06 0 2.91604999999994e-06 0 2.91999999999994e-06 0 2.92009999999994e-06 1 2.92049999999994e-06 1 2.92054999999994e-06 0 2.92199999999994e-06 0 2.92204999999994e-06 0 2.92599999999994e-06 0 2.92609999999994e-06 1 2.92649999999994e-06 1 2.92654999999994e-06 0 2.92799999999994e-06 0 2.92804999999994e-06 0 2.93199999999994e-06 0 2.93209999999994e-06 1 2.93249999999994e-06 1 2.93254999999994e-06 0 2.93399999999994e-06 0 2.93404999999994e-06 0 2.93799999999994e-06 0 2.93809999999994e-06 1 2.93849999999994e-06 1 2.93854999999994e-06 0 2.93999999999994e-06 0 2.94004999999994e-06 0 2.94399999999994e-06 0 2.94409999999994e-06 1 2.94449999999994e-06 1 2.94454999999994e-06 0 2.94599999999994e-06 0 2.94604999999994e-06 0 2.94999999999994e-06 0 2.95009999999994e-06 1 2.95049999999994e-06 1 2.95054999999994e-06 0 2.95199999999994e-06 0 2.95204999999994e-06 0 2.95599999999994e-06 0 2.95609999999994e-06 1 2.95649999999994e-06 1 2.95654999999994e-06 0 2.95799999999994e-06 0 2.95804999999994e-06 0 2.96199999999994e-06 0 2.96209999999994e-06 1 2.96249999999994e-06 1 2.96254999999994e-06 0 2.96399999999994e-06 0 2.96404999999994e-06 0 2.96799999999994e-06 0 2.96809999999994e-06 1 2.96849999999994e-06 1 2.96854999999994e-06 0 2.96999999999994e-06 0 2.97004999999994e-06 0 2.97399999999994e-06 0 2.97409999999994e-06 1 2.97449999999994e-06 1 2.97454999999994e-06 0 2.97599999999994e-06 0 2.97604999999994e-06 0 2.97999999999994e-06 0 2.98009999999994e-06 1 2.98049999999994e-06 1 2.98054999999994e-06 0 2.98199999999994e-06 0 2.98204999999994e-06 0 2.98599999999994e-06 0 2.98609999999993e-06 1 2.98649999999993e-06 1 2.98654999999994e-06 0 2.98799999999993e-06 0 2.98804999999993e-06 0 2.99199999999993e-06 0 2.99209999999993e-06 1 2.99249999999993e-06 1 2.99254999999993e-06 0 2.99399999999993e-06 0 2.99404999999993e-06 0 2.99799999999993e-06 0 2.99809999999993e-06 1 2.99849999999993e-06 1 2.99854999999993e-06 0 2.99999999999993e-06 0 3.00004999999993e-06 0 3.00399999999993e-06 0 3.00409999999993e-06 1 3.00449999999993e-06 1 3.00454999999993e-06 0 3.00599999999993e-06 0 3.00604999999993e-06 0 3.00999999999993e-06 0 3.01009999999993e-06 1 3.01049999999993e-06 1 3.01054999999993e-06 0 3.01199999999993e-06 0 3.01204999999993e-06 0 3.01599999999993e-06 0 3.01609999999993e-06 1 3.01649999999993e-06 1 3.01654999999993e-06 0 3.01799999999993e-06 0 3.01804999999993e-06 0 3.02199999999993e-06 0 3.02209999999993e-06 1 3.02249999999993e-06 1 3.02254999999993e-06 0 3.02399999999993e-06 0 3.02404999999993e-06 0 3.02799999999993e-06 0 3.02809999999993e-06 1 3.02849999999993e-06 1 3.02854999999993e-06 0 3.02999999999993e-06 0 3.03004999999993e-06 0 3.03399999999993e-06 0 3.03409999999993e-06 1 3.03449999999993e-06 1 3.03454999999993e-06 0 3.03599999999993e-06 0 3.03604999999993e-06 0 3.03999999999993e-06 0 3.04009999999993e-06 1 3.04049999999993e-06 1 3.04054999999993e-06 0 3.04199999999993e-06 0 3.04204999999993e-06 0 3.04599999999993e-06 0 3.04609999999993e-06 1 3.04649999999993e-06 1 3.04654999999993e-06 0 3.04799999999993e-06 0 3.04804999999993e-06 0 3.05199999999993e-06 0 3.05209999999993e-06 1 3.05249999999993e-06 1 3.05254999999993e-06 0 3.05399999999993e-06 0 3.05404999999993e-06 0 3.05799999999993e-06 0 3.05809999999993e-06 1 3.05849999999993e-06 1 3.05854999999993e-06 0 3.05999999999993e-06 0 3.06004999999993e-06 0 3.06399999999993e-06 0 3.06409999999993e-06 1 3.06449999999993e-06 1 3.06454999999993e-06 0 3.06599999999993e-06 0 3.06604999999993e-06 0 3.06999999999993e-06 0 3.07009999999993e-06 1 3.07049999999993e-06 1 3.07054999999993e-06 0 3.07599999999993e-06 0]
parameters wave_SAN = [0 0 4.5e-09 0 4.6e-09 1 5.9e-09 1 5.95e-09 0 6e-09 0 6.05e-09 0 1.05e-08 0 1.06e-08 1 1.19e-08 1 1.195e-08 0 1.2e-08 0 1.205e-08 0 1.65e-08 0 1.66e-08 1 1.79e-08 1 1.795e-08 0 1.8e-08 0 1.805e-08 0 2.25e-08 0 2.26e-08 1 2.39e-08 1 2.395e-08 0 2.4e-08 0 2.405e-08 0 2.85e-08 0 2.86e-08 1 2.99e-08 1 2.995e-08 0 3e-08 0 3.005e-08 0 3.45e-08 0 3.46e-08 1 3.59e-08 1 3.595e-08 0 3.6e-08 0 3.605e-08 0 4.05e-08 0 4.06e-08 1 4.19e-08 1 4.195e-08 0 4.2e-08 0 4.205e-08 0 4.65e-08 0 4.66e-08 1 4.79e-08 1 4.795e-08 0 4.8e-08 0 4.805e-08 0 5.25e-08 0 5.26e-08 1 5.39e-08 1 5.395e-08 0 5.4e-08 0 5.405e-08 0 5.85e-08 0 5.86e-08 1 5.99e-08 1 5.995e-08 0 6e-08 0 6.005e-08 0 6.45e-08 0 6.46e-08 1 6.59e-08 1 6.595e-08 0 6.6e-08 0 6.605e-08 0 7.05e-08 0 7.06e-08 1 7.19e-08 1 7.195e-08 0 7.2e-08 0 7.205e-08 0 7.65e-08 0 7.66e-08 1 7.79e-08 1 7.795e-08 0 7.8e-08 0 7.805e-08 0 8.25e-08 0 8.26e-08 1 8.39e-08 1 8.395e-08 0 8.4e-08 0 8.405e-08 0 8.85e-08 0 8.86e-08 1 8.99e-08 1 8.995e-08 0 9e-08 0 9.005e-08 0 9.45e-08 0 9.46e-08 1 9.59e-08 1 9.595e-08 0 9.6e-08 0 9.605e-08 0 1.005e-07 0 1.006e-07 1 1.019e-07 1 1.0195e-07 0 1.02e-07 0 1.0205e-07 0 1.065e-07 0 1.066e-07 1 1.079e-07 1 1.0795e-07 0 1.08e-07 0 1.0805e-07 0 1.125e-07 0 1.126e-07 1 1.139e-07 1 1.1395e-07 0 1.14e-07 0 1.1405e-07 0 1.185e-07 0 1.186e-07 1 1.199e-07 1 1.1995e-07 0 1.2e-07 0 1.2005e-07 0 1.245e-07 0 1.246e-07 1 1.259e-07 1 1.2595e-07 0 1.26e-07 0 1.2605e-07 0 1.305e-07 0 1.306e-07 1 1.319e-07 1 1.3195e-07 0 1.32e-07 0 1.3205e-07 0 1.365e-07 0 1.366e-07 1 1.379e-07 1 1.3795e-07 0 1.38e-07 0 1.3805e-07 0 1.425e-07 0 1.426e-07 1 1.439e-07 1 1.4395e-07 0 1.44e-07 0 1.4405e-07 0 1.485e-07 0 1.486e-07 1 1.499e-07 1 1.4995e-07 0 1.5e-07 0 1.5005e-07 0 1.545e-07 0 1.546e-07 1 1.559e-07 1 1.5595e-07 0 1.56e-07 0 1.5605e-07 0 1.605e-07 0 1.606e-07 1 1.619e-07 1 1.6195e-07 0 1.62e-07 0 1.6205e-07 0 1.665e-07 0 1.666e-07 1 1.679e-07 1 1.6795e-07 0 1.68e-07 0 1.6805e-07 0 1.725e-07 0 1.726e-07 1 1.739e-07 1 1.7395e-07 0 1.74e-07 0 1.7405e-07 0 1.785e-07 0 1.786e-07 1 1.799e-07 1 1.7995e-07 0 1.8e-07 0 1.8005e-07 0 1.845e-07 0 1.846e-07 1 1.859e-07 1 1.8595e-07 0 1.86e-07 0 1.8605e-07 0 1.905e-07 0 1.906e-07 1 1.919e-07 1 1.9195e-07 0 1.92e-07 0 1.9205e-07 0 1.965e-07 0 1.966e-07 1 1.979e-07 1 1.9795e-07 0 1.98e-07 0 1.9805e-07 0 2.025e-07 0 2.026e-07 1 2.039e-07 1 2.0395e-07 0 2.04e-07 0 2.0405e-07 0 2.085e-07 0 2.086e-07 1 2.099e-07 1 2.0995e-07 0 2.1e-07 0 2.1005e-07 0 2.145e-07 0 2.146e-07 1 2.159e-07 1 2.1595e-07 0 2.16e-07 0 2.1605e-07 0 2.205e-07 0 2.206e-07 1 2.219e-07 1 2.2195e-07 0 2.22e-07 0 2.2205e-07 0 2.265e-07 0 2.266e-07 1 2.279e-07 1 2.2795e-07 0 2.28e-07 0 2.2805e-07 0 2.325e-07 0 2.326e-07 1 2.339e-07 1 2.3395e-07 0 2.34e-07 0 2.3405e-07 0 2.385e-07 0 2.386e-07 1 2.399e-07 1 2.3995e-07 0 2.4e-07 0 2.4005e-07 0 2.445e-07 0 2.446e-07 1 2.459e-07 1 2.4595e-07 0 2.46e-07 0 2.4605e-07 0 2.505e-07 0 2.506e-07 1 2.519e-07 1 2.5195e-07 0 2.52e-07 0 2.5205e-07 0 2.565e-07 0 2.566e-07 1 2.579e-07 1 2.5795e-07 0 2.58e-07 0 2.5805e-07 0 2.625e-07 0 2.626e-07 1 2.639e-07 1 2.6395e-07 0 2.64e-07 0 2.6405e-07 0 2.685e-07 0 2.686e-07 1 2.699e-07 1 2.6995e-07 0 2.7e-07 0 2.7005e-07 0 2.745e-07 0 2.746e-07 1 2.759e-07 1 2.7595e-07 0 2.76e-07 0 2.7605e-07 0 2.805e-07 0 2.806e-07 1 2.819e-07 1 2.8195e-07 0 2.82e-07 0 2.8205e-07 0 2.865e-07 0 2.866e-07 1 2.879e-07 1 2.8795e-07 0 2.88e-07 0 2.8805e-07 0 2.925e-07 0 2.926e-07 1 2.939e-07 1 2.9395e-07 0 2.94e-07 0 2.9405e-07 0 2.985e-07 0 2.986e-07 1 2.999e-07 1 2.9995e-07 0 3e-07 0 3.0005e-07 0 3.045e-07 0 3.046e-07 1 3.059e-07 1 3.0595e-07 0 3.06e-07 0 3.0605e-07 0 3.105e-07 0 3.106e-07 1 3.119e-07 1 3.1195e-07 0 3.12e-07 0 3.1205e-07 0 3.165e-07 0 3.166e-07 1 3.179e-07 1 3.1795e-07 0 3.18e-07 0 3.1805e-07 0 3.225e-07 0 3.226e-07 1 3.239e-07 1 3.2395e-07 0 3.24e-07 0 3.2405e-07 0 3.285e-07 0 3.286e-07 1 3.299e-07 1 3.2995e-07 0 3.3e-07 0 3.3005e-07 0 3.345e-07 0 3.346e-07 1 3.359e-07 1 3.3595e-07 0 3.36e-07 0 3.3605e-07 0 3.405e-07 0 3.406e-07 1 3.419e-07 1 3.4195e-07 0 3.42e-07 0 3.4205e-07 0 3.46500000000001e-07 0 3.46600000000001e-07 1 3.47900000000001e-07 1 3.47950000000001e-07 0 3.48000000000001e-07 0 3.48050000000001e-07 0 3.52500000000001e-07 0 3.52600000000001e-07 1 3.53900000000001e-07 1 3.53950000000001e-07 0 3.54000000000001e-07 0 3.54050000000001e-07 0 3.58500000000001e-07 0 3.58600000000001e-07 1 3.59900000000001e-07 1 3.59950000000001e-07 0 3.60000000000001e-07 0 3.60050000000001e-07 0 3.64500000000001e-07 0 3.64600000000001e-07 1 3.65900000000001e-07 1 3.65950000000001e-07 0 3.66000000000001e-07 0 3.66050000000001e-07 0 3.70500000000001e-07 0 3.70600000000001e-07 1 3.71900000000001e-07 1 3.71950000000001e-07 0 3.72000000000001e-07 0 3.72050000000001e-07 0 3.76500000000001e-07 0 3.76600000000001e-07 1 3.77900000000001e-07 1 3.77950000000001e-07 0 3.78000000000001e-07 0 3.78050000000001e-07 0 3.82500000000001e-07 0 3.82600000000001e-07 1 3.83900000000001e-07 1 3.83950000000001e-07 0 3.84000000000001e-07 0 3.84050000000001e-07 0 3.88500000000001e-07 0 3.88600000000001e-07 1 3.89900000000001e-07 1 3.89950000000001e-07 0 3.90000000000001e-07 0 3.90050000000001e-07 0 3.94500000000001e-07 0 3.94600000000001e-07 1 3.95900000000001e-07 1 3.95950000000001e-07 0 3.96000000000001e-07 0 3.96050000000001e-07 0 4.00500000000001e-07 0 4.00600000000001e-07 1 4.01900000000001e-07 1 4.01950000000001e-07 0 4.02000000000001e-07 0 4.02050000000001e-07 0 4.06500000000001e-07 0 4.06600000000001e-07 1 4.07900000000001e-07 1 4.07950000000001e-07 0 4.08000000000001e-07 0 4.08050000000001e-07 0 4.12500000000001e-07 0 4.12600000000001e-07 1 4.13900000000001e-07 1 4.13950000000001e-07 0 4.14000000000001e-07 0 4.14050000000001e-07 0 4.18500000000001e-07 0 4.18600000000001e-07 1 4.19900000000001e-07 1 4.19950000000001e-07 0 4.20000000000001e-07 0 4.20050000000001e-07 0 4.24500000000001e-07 0 4.24600000000001e-07 1 4.25900000000001e-07 1 4.25950000000001e-07 0 4.26000000000001e-07 0 4.26050000000001e-07 0 4.30500000000001e-07 0 4.30600000000001e-07 1 4.31900000000001e-07 1 4.31950000000001e-07 0 4.32000000000001e-07 0 4.32050000000001e-07 0 4.36500000000001e-07 0 4.36600000000001e-07 1 4.37900000000001e-07 1 4.37950000000001e-07 0 4.38000000000001e-07 0 4.38050000000001e-07 0 4.42500000000001e-07 0 4.42600000000001e-07 1 4.43900000000001e-07 1 4.43950000000001e-07 0 4.44000000000001e-07 0 4.44050000000001e-07 0 4.48500000000001e-07 0 4.48600000000001e-07 1 4.49900000000001e-07 1 4.49950000000001e-07 0 4.50000000000001e-07 0 4.50050000000001e-07 0 4.54500000000001e-07 0 4.54600000000001e-07 1 4.55900000000001e-07 1 4.55950000000001e-07 0 4.56000000000001e-07 0 4.56050000000001e-07 0 4.60500000000001e-07 0 4.60600000000001e-07 1 4.61900000000001e-07 1 4.61950000000001e-07 0 4.62000000000001e-07 0 4.62050000000001e-07 0 4.66500000000001e-07 0 4.66600000000001e-07 1 4.67900000000001e-07 1 4.67950000000001e-07 0 4.68000000000001e-07 0 4.68050000000001e-07 0 4.72500000000001e-07 0 4.72600000000001e-07 1 4.73900000000001e-07 1 4.73950000000001e-07 0 4.74000000000001e-07 0 4.74050000000001e-07 0 4.78500000000001e-07 0 4.78600000000001e-07 1 4.79900000000001e-07 1 4.79950000000001e-07 0 4.80000000000001e-07 0 4.80050000000001e-07 0 4.84500000000001e-07 0 4.84600000000001e-07 1 4.85900000000001e-07 1 4.85950000000001e-07 0 4.86000000000001e-07 0 4.86050000000001e-07 0 4.90500000000001e-07 0 4.90600000000001e-07 1 4.91900000000001e-07 1 4.91950000000001e-07 0 4.92000000000001e-07 0 4.92050000000001e-07 0 4.96500000000001e-07 0 4.96600000000001e-07 1 4.97900000000001e-07 1 4.97950000000001e-07 0 4.98000000000001e-07 0 4.98050000000001e-07 0 5.02500000000001e-07 0 5.02600000000001e-07 1 5.03900000000001e-07 1 5.03950000000001e-07 0 5.04000000000001e-07 0 5.04050000000001e-07 0 5.08500000000001e-07 0 5.08600000000001e-07 1 5.09900000000001e-07 1 5.09950000000001e-07 0 5.10000000000001e-07 0 5.10050000000001e-07 0 5.14500000000001e-07 0 5.14600000000001e-07 1 5.15900000000001e-07 1 5.15950000000001e-07 0 5.16000000000001e-07 0 5.16050000000001e-07 0 5.20500000000001e-07 0 5.20600000000001e-07 1 5.21900000000001e-07 1 5.21950000000001e-07 0 5.22000000000001e-07 0 5.22050000000001e-07 0 5.26500000000001e-07 0 5.26600000000001e-07 1 5.27900000000001e-07 1 5.27950000000001e-07 0 5.28000000000001e-07 0 5.28050000000001e-07 0 5.32500000000001e-07 0 5.32600000000001e-07 1 5.33900000000001e-07 1 5.33950000000001e-07 0 5.34000000000001e-07 0 5.34050000000001e-07 0 5.38500000000001e-07 0 5.38600000000001e-07 1 5.39900000000001e-07 1 5.39950000000001e-07 0 5.40000000000001e-07 0 5.40050000000001e-07 0 5.44500000000001e-07 0 5.44600000000001e-07 1 5.45900000000001e-07 1 5.45950000000001e-07 0 5.46000000000001e-07 0 5.46050000000001e-07 0 5.50500000000001e-07 0 5.50600000000001e-07 1 5.51900000000001e-07 1 5.51950000000001e-07 0 5.52000000000001e-07 0 5.52050000000001e-07 0 5.56500000000001e-07 0 5.56600000000001e-07 1 5.57900000000001e-07 1 5.57950000000001e-07 0 5.58000000000001e-07 0 5.58050000000001e-07 0 5.62500000000001e-07 0 5.62600000000002e-07 1 5.63900000000001e-07 1 5.63950000000001e-07 0 5.64000000000002e-07 0 5.64050000000002e-07 0 5.68500000000002e-07 0 5.68600000000002e-07 1 5.69900000000002e-07 1 5.69950000000002e-07 0 5.70000000000002e-07 0 5.70050000000002e-07 0 5.74500000000002e-07 0 5.74600000000002e-07 1 5.75900000000002e-07 1 5.75950000000002e-07 0 5.76000000000002e-07 0 5.76050000000002e-07 0 5.80500000000002e-07 0 5.80600000000002e-07 1 5.81900000000002e-07 1 5.81950000000002e-07 0 5.82000000000002e-07 0 5.82050000000002e-07 0 5.86500000000002e-07 0 5.86600000000002e-07 1 5.87900000000002e-07 1 5.87950000000002e-07 0 5.88000000000002e-07 0 5.88050000000002e-07 0 5.92500000000002e-07 0 5.92600000000002e-07 1 5.93900000000002e-07 1 5.93950000000002e-07 0 5.94000000000002e-07 0 5.94050000000002e-07 0 5.98500000000002e-07 0 5.98600000000002e-07 1 5.99900000000002e-07 1 5.99950000000002e-07 0 6.00000000000002e-07 0 6.00050000000002e-07 0 6.04500000000002e-07 0 6.04600000000002e-07 1 6.05900000000002e-07 1 6.05950000000002e-07 0 6.06000000000002e-07 0 6.06050000000002e-07 0 6.10500000000002e-07 0 6.10600000000002e-07 1 6.11900000000002e-07 1 6.11950000000002e-07 0 6.12000000000002e-07 0 6.12050000000002e-07 0 6.16500000000002e-07 0 6.16600000000002e-07 1 6.17900000000002e-07 1 6.17950000000002e-07 0 6.18000000000002e-07 0 6.18050000000002e-07 0 6.22500000000002e-07 0 6.22600000000002e-07 1 6.23900000000002e-07 1 6.23950000000002e-07 0 6.24000000000002e-07 0 6.24050000000002e-07 0 6.28500000000002e-07 0 6.28600000000002e-07 1 6.29900000000002e-07 1 6.29950000000002e-07 0 6.30000000000002e-07 0 6.30050000000002e-07 0 6.34500000000002e-07 0 6.34600000000002e-07 1 6.35900000000002e-07 1 6.35950000000002e-07 0 6.36000000000002e-07 0 6.36050000000002e-07 0 6.40500000000002e-07 0 6.40600000000002e-07 1 6.41900000000002e-07 1 6.41950000000002e-07 0 6.42000000000002e-07 0 6.42050000000002e-07 0 6.46500000000002e-07 0 6.46600000000002e-07 1 6.47900000000002e-07 1 6.47950000000002e-07 0 6.48000000000002e-07 0 6.48050000000002e-07 0 6.52500000000002e-07 0 6.52600000000002e-07 1 6.53900000000002e-07 1 6.53950000000002e-07 0 6.54000000000002e-07 0 6.54050000000002e-07 0 6.58500000000002e-07 0 6.58600000000002e-07 1 6.59900000000002e-07 1 6.59950000000002e-07 0 6.60000000000002e-07 0 6.60050000000002e-07 0 6.64500000000002e-07 0 6.64600000000002e-07 1 6.65900000000002e-07 1 6.65950000000002e-07 0 6.66000000000002e-07 0 6.66050000000002e-07 0 6.70500000000002e-07 0 6.70600000000002e-07 1 6.71900000000002e-07 1 6.71950000000002e-07 0 6.72000000000002e-07 0 6.72050000000002e-07 0 6.76500000000002e-07 0 6.76600000000002e-07 1 6.77900000000002e-07 1 6.77950000000002e-07 0 6.78000000000002e-07 0 6.78050000000002e-07 0 6.82500000000002e-07 0 6.82600000000002e-07 1 6.83900000000002e-07 1 6.83950000000002e-07 0 6.84000000000002e-07 0 6.84050000000002e-07 0 6.88500000000002e-07 0 6.88600000000002e-07 1 6.89900000000002e-07 1 6.89950000000002e-07 0 6.90000000000002e-07 0 6.90050000000002e-07 0 6.94500000000002e-07 0 6.94600000000002e-07 1 6.95900000000002e-07 1 6.95950000000002e-07 0 6.96000000000002e-07 0 6.96050000000002e-07 0 7.00500000000002e-07 0 7.00600000000002e-07 1 7.01900000000002e-07 1 7.01950000000002e-07 0 7.02000000000002e-07 0 7.02050000000002e-07 0 7.06500000000002e-07 0 7.06600000000002e-07 1 7.07900000000002e-07 1 7.07950000000002e-07 0 7.08000000000002e-07 0 7.08050000000002e-07 0 7.12500000000002e-07 0 7.12600000000002e-07 1 7.13900000000002e-07 1 7.13950000000002e-07 0 7.14000000000002e-07 0 7.14050000000002e-07 0 7.18500000000002e-07 0 7.18600000000002e-07 1 7.19900000000002e-07 1 7.19950000000002e-07 0 7.20000000000002e-07 0 7.20050000000002e-07 0 7.24500000000002e-07 0 7.24600000000002e-07 1 7.25900000000002e-07 1 7.25950000000002e-07 0 7.26000000000002e-07 0 7.26050000000002e-07 0 7.30500000000002e-07 0 7.30600000000002e-07 1 7.31900000000002e-07 1 7.31950000000002e-07 0 7.32000000000002e-07 0 7.32050000000002e-07 0 7.36500000000002e-07 0 7.36600000000002e-07 1 7.37900000000002e-07 1 7.37950000000002e-07 0 7.38000000000002e-07 0 7.38050000000002e-07 0 7.42500000000002e-07 0 7.42600000000002e-07 1 7.43900000000002e-07 1 7.43950000000002e-07 0 7.44000000000002e-07 0 7.44050000000002e-07 0 7.48500000000002e-07 0 7.48600000000002e-07 1 7.49900000000002e-07 1 7.49950000000002e-07 0 7.50000000000002e-07 0 7.50050000000002e-07 0 7.54500000000002e-07 0 7.54600000000002e-07 1 7.55900000000002e-07 1 7.55950000000002e-07 0 7.56000000000002e-07 0 7.56050000000002e-07 0 7.60500000000002e-07 0 7.60600000000002e-07 1 7.61900000000002e-07 1 7.61950000000002e-07 0 7.62000000000002e-07 0 7.62050000000002e-07 0 7.66500000000002e-07 0 7.66600000000002e-07 1 7.67900000000002e-07 1 7.67950000000002e-07 0 7.68000000000002e-07 0 7.68050000000002e-07 0 7.72500000000002e-07 0 7.72600000000002e-07 1 7.73900000000002e-07 1 7.73950000000002e-07 0 7.74000000000002e-07 0 7.74050000000002e-07 0 7.78500000000002e-07 0 7.78600000000002e-07 1 7.79900000000002e-07 1 7.79950000000002e-07 0 7.80000000000002e-07 0 7.80050000000002e-07 0 7.84500000000003e-07 0 7.84600000000003e-07 1 7.85900000000003e-07 1 7.85950000000003e-07 0 7.86000000000003e-07 0 7.86050000000003e-07 0 7.90500000000003e-07 0 7.90600000000003e-07 1 7.91900000000003e-07 1 7.91950000000003e-07 0 7.92000000000003e-07 0 7.92050000000003e-07 0 7.96500000000003e-07 0 7.96600000000003e-07 1 7.97900000000003e-07 1 7.97950000000003e-07 0 7.98000000000003e-07 0 7.98050000000003e-07 0 8.02500000000003e-07 0 8.02600000000003e-07 1 8.03900000000003e-07 1 8.03950000000003e-07 0 8.04000000000003e-07 0 8.04050000000003e-07 0 8.08500000000003e-07 0 8.08600000000003e-07 1 8.09900000000003e-07 1 8.09950000000003e-07 0 8.10000000000003e-07 0 8.10050000000003e-07 0 8.14500000000003e-07 0 8.14600000000003e-07 1 8.15900000000003e-07 1 8.15950000000003e-07 0 8.16000000000003e-07 0 8.16050000000003e-07 0 8.20500000000003e-07 0 8.20600000000003e-07 1 8.21900000000003e-07 1 8.21950000000003e-07 0 8.22000000000003e-07 0 8.22050000000003e-07 0 8.26500000000003e-07 0 8.26600000000003e-07 1 8.27900000000003e-07 1 8.27950000000003e-07 0 8.28000000000003e-07 0 8.28050000000003e-07 0 8.32500000000003e-07 0 8.32600000000003e-07 1 8.33900000000003e-07 1 8.33950000000003e-07 0 8.34000000000003e-07 0 8.34050000000003e-07 0 8.38500000000003e-07 0 8.38600000000003e-07 1 8.39900000000003e-07 1 8.39950000000003e-07 0 8.40000000000003e-07 0 8.40050000000003e-07 0 8.44500000000003e-07 0 8.44600000000003e-07 1 8.45900000000003e-07 1 8.45950000000003e-07 0 8.46000000000003e-07 0 8.46050000000003e-07 0 8.50500000000003e-07 0 8.50600000000003e-07 1 8.51900000000003e-07 1 8.51950000000003e-07 0 8.52000000000003e-07 0 8.52050000000003e-07 0 8.56500000000003e-07 0 8.56600000000003e-07 1 8.57900000000003e-07 1 8.57950000000003e-07 0 8.58000000000003e-07 0 8.58050000000003e-07 0 8.62500000000003e-07 0 8.62600000000003e-07 1 8.63900000000003e-07 1 8.63950000000003e-07 0 8.64000000000003e-07 0 8.64050000000003e-07 0 8.68500000000003e-07 0 8.68600000000003e-07 1 8.69900000000003e-07 1 8.69950000000003e-07 0 8.70000000000003e-07 0 8.70050000000003e-07 0 8.74500000000003e-07 0 8.74600000000003e-07 1 8.75900000000003e-07 1 8.75950000000003e-07 0 8.76000000000003e-07 0 8.76050000000003e-07 0 8.80500000000003e-07 0 8.80600000000003e-07 1 8.81900000000003e-07 1 8.81950000000003e-07 0 8.82000000000003e-07 0 8.82050000000003e-07 0 8.86500000000003e-07 0 8.86600000000003e-07 1 8.87900000000003e-07 1 8.87950000000003e-07 0 8.88000000000003e-07 0 8.88050000000003e-07 0 8.92500000000003e-07 0 8.92600000000003e-07 1 8.93900000000003e-07 1 8.93950000000003e-07 0 8.94000000000003e-07 0 8.94050000000003e-07 0 8.98500000000003e-07 0 8.98600000000003e-07 1 8.99900000000003e-07 1 8.99950000000003e-07 0 9.00000000000003e-07 0 9.00050000000003e-07 0 9.04500000000003e-07 0 9.04600000000003e-07 1 9.05900000000003e-07 1 9.05950000000003e-07 0 9.06000000000003e-07 0 9.06050000000003e-07 0 9.10500000000003e-07 0 9.10600000000003e-07 1 9.11900000000003e-07 1 9.11950000000003e-07 0 9.12000000000003e-07 0 9.12050000000003e-07 0 9.16500000000003e-07 0 9.16600000000003e-07 1 9.17900000000003e-07 1 9.17950000000003e-07 0 9.18000000000003e-07 0 9.18050000000003e-07 0 9.22500000000003e-07 0 9.22600000000003e-07 1 9.23900000000003e-07 1 9.23950000000003e-07 0 9.24000000000003e-07 0 9.24050000000003e-07 0 9.28500000000003e-07 0 9.28600000000003e-07 1 9.29900000000003e-07 1 9.29950000000003e-07 0 9.30000000000003e-07 0 9.30050000000003e-07 0 9.34500000000003e-07 0 9.34600000000003e-07 1 9.35900000000003e-07 1 9.35950000000003e-07 0 9.36000000000003e-07 0 9.36050000000003e-07 0 9.40500000000003e-07 0 9.40600000000003e-07 1 9.41900000000003e-07 1 9.41950000000003e-07 0 9.42000000000003e-07 0 9.42050000000003e-07 0 9.46500000000003e-07 0 9.46600000000003e-07 1 9.47900000000003e-07 1 9.47950000000003e-07 0 9.48000000000003e-07 0 9.48050000000003e-07 0 9.52500000000003e-07 0 9.52600000000003e-07 1 9.53900000000003e-07 1 9.53950000000003e-07 0 9.54000000000003e-07 0 9.54050000000003e-07 0 9.58500000000003e-07 0 9.58600000000003e-07 1 9.59900000000003e-07 1 9.59950000000003e-07 0 9.60000000000003e-07 0 9.60050000000003e-07 0 9.64500000000003e-07 0 9.64600000000003e-07 1 9.65900000000003e-07 1 9.65950000000003e-07 0 9.66000000000003e-07 0 9.66050000000003e-07 0 9.70500000000003e-07 0 9.70600000000003e-07 1 9.71900000000003e-07 1 9.71950000000003e-07 0 9.72000000000003e-07 0 9.72050000000003e-07 0 9.76500000000003e-07 0 9.76600000000003e-07 1 9.77900000000003e-07 1 9.77950000000003e-07 0 9.78000000000003e-07 0 9.78050000000003e-07 0 9.82500000000003e-07 0 9.82600000000003e-07 1 9.83900000000003e-07 1 9.83950000000003e-07 0 9.84000000000003e-07 0 9.84050000000003e-07 0 9.88500000000003e-07 0 9.88600000000003e-07 1 9.89900000000003e-07 1 9.89950000000003e-07 0 9.90000000000003e-07 0 9.90050000000003e-07 0 9.94500000000003e-07 0 9.94600000000003e-07 1 9.95900000000003e-07 1 9.95950000000003e-07 0 9.96000000000003e-07 0 9.96050000000003e-07 0 1.0005e-06 0 1.0006e-06 1 1.0019e-06 1 1.00195e-06 0 1.002e-06 0 1.00205e-06 0 1.0065e-06 0 1.0066e-06 1 1.0079e-06 1 1.00795e-06 0 1.008e-06 0 1.00805e-06 0 1.0125e-06 0 1.0126e-06 1 1.0139e-06 1 1.01395e-06 0 1.014e-06 0 1.01405e-06 0 1.0185e-06 0 1.0186e-06 1 1.0199e-06 1 1.01995e-06 0 1.02e-06 0 1.02005e-06 0 1.0245e-06 0 1.0246e-06 1 1.0259e-06 1 1.02595e-06 0 1.026e-06 0 1.02605e-06 0 1.0305e-06 0 1.0306e-06 1 1.0319e-06 1 1.03195e-06 0 1.032e-06 0 1.03205e-06 0 1.0365e-06 0 1.0366e-06 1 1.0379e-06 1 1.03795e-06 0 1.038e-06 0 1.03805e-06 0 1.0425e-06 0 1.0426e-06 1 1.0439e-06 1 1.04395e-06 0 1.044e-06 0 1.04405e-06 0 1.0485e-06 0 1.0486e-06 1 1.0499e-06 1 1.04995e-06 0 1.05e-06 0 1.05005e-06 0 1.0545e-06 0 1.0546e-06 1 1.0559e-06 1 1.05595e-06 0 1.056e-06 0 1.05605e-06 0 1.0605e-06 0 1.0606e-06 1 1.0619e-06 1 1.06195e-06 0 1.062e-06 0 1.06205e-06 0 1.0665e-06 0 1.0666e-06 1 1.0679e-06 1 1.06795e-06 0 1.068e-06 0 1.06805e-06 0 1.0725e-06 0 1.0726e-06 1 1.0739e-06 1 1.07395e-06 0 1.074e-06 0 1.07405e-06 0 1.0785e-06 0 1.0786e-06 1 1.0799e-06 1 1.07995e-06 0 1.08e-06 0 1.08005e-06 0 1.0845e-06 0 1.0846e-06 1 1.0859e-06 1 1.08595e-06 0 1.086e-06 0 1.08605e-06 0 1.0905e-06 0 1.0906e-06 1 1.0919e-06 1 1.09195e-06 0 1.092e-06 0 1.09205e-06 0 1.0965e-06 0 1.0966e-06 1 1.0979e-06 1 1.09795e-06 0 1.098e-06 0 1.09805e-06 0 1.1025e-06 0 1.1026e-06 1 1.1039e-06 1 1.10395e-06 0 1.104e-06 0 1.10405e-06 0 1.1085e-06 0 1.1086e-06 1 1.1099e-06 1 1.10995e-06 0 1.11e-06 0 1.11005e-06 0 1.1145e-06 0 1.1146e-06 1 1.1159e-06 1 1.11595e-06 0 1.116e-06 0 1.11605e-06 0 1.1205e-06 0 1.1206e-06 1 1.1219e-06 1 1.12195e-06 0 1.122e-06 0 1.12205e-06 0 1.1265e-06 0 1.1266e-06 1 1.1279e-06 1 1.12795e-06 0 1.128e-06 0 1.12805e-06 0 1.1325e-06 0 1.1326e-06 1 1.1339e-06 1 1.13395e-06 0 1.134e-06 0 1.13405e-06 0 1.1385e-06 0 1.1386e-06 1 1.1399e-06 1 1.13995e-06 0 1.14e-06 0 1.14005e-06 0 1.1445e-06 0 1.1446e-06 1 1.1459e-06 1 1.14595e-06 0 1.146e-06 0 1.14605e-06 0 1.1505e-06 0 1.1506e-06 1 1.1519e-06 1 1.15195e-06 0 1.152e-06 0 1.15205e-06 0 1.1565e-06 0 1.1566e-06 1 1.1579e-06 1 1.15795e-06 0 1.158e-06 0 1.15805e-06 0 1.1625e-06 0 1.1626e-06 1 1.1639e-06 1 1.16395e-06 0 1.164e-06 0 1.16405e-06 0 1.1685e-06 0 1.1686e-06 1 1.1699e-06 1 1.16995e-06 0 1.17e-06 0 1.17005e-06 0 1.1745e-06 0 1.1746e-06 1 1.1759e-06 1 1.17595e-06 0 1.176e-06 0 1.17605e-06 0 1.1805e-06 0 1.1806e-06 1 1.1819e-06 1 1.18195e-06 0 1.182e-06 0 1.18205e-06 0 1.1865e-06 0 1.1866e-06 1 1.1879e-06 1 1.18795e-06 0 1.188e-06 0 1.18805e-06 0 1.1925e-06 0 1.1926e-06 1 1.1939e-06 1 1.19395e-06 0 1.194e-06 0 1.19405e-06 0 1.1985e-06 0 1.1986e-06 1 1.1999e-06 1 1.19995e-06 0 1.2e-06 0 1.20005e-06 0 1.2045e-06 0 1.2046e-06 1 1.2059e-06 1 1.20595e-06 0 1.206e-06 0 1.20605e-06 0 1.2105e-06 0 1.2106e-06 1 1.2119e-06 1 1.21195e-06 0 1.212e-06 0 1.21205e-06 0 1.2165e-06 0 1.2166e-06 1 1.2179e-06 1 1.21795e-06 0 1.218e-06 0 1.21805e-06 0 1.2225e-06 0 1.2226e-06 1 1.2239e-06 1 1.22395e-06 0 1.224e-06 0 1.22405e-06 0 1.2285e-06 0 1.2286e-06 1 1.2299e-06 1 1.22995e-06 0 1.23e-06 0 1.23005e-06 0 1.2345e-06 0 1.2346e-06 1 1.2359e-06 1 1.23595e-06 0 1.236e-06 0 1.23605e-06 0 1.2405e-06 0 1.2406e-06 1 1.2419e-06 1 1.24195e-06 0 1.242e-06 0 1.24205e-06 0 1.2465e-06 0 1.2466e-06 1 1.2479e-06 1 1.24795e-06 0 1.248e-06 0 1.24805e-06 0 1.2525e-06 0 1.2526e-06 1 1.2539e-06 1 1.25395e-06 0 1.254e-06 0 1.25405e-06 0 1.2585e-06 0 1.2586e-06 1 1.2599e-06 1 1.25995e-06 0 1.26e-06 0 1.26005e-06 0 1.2645e-06 0 1.2646e-06 1 1.2659e-06 1 1.26595e-06 0 1.266e-06 0 1.26605e-06 0 1.2705e-06 0 1.2706e-06 1 1.2719e-06 1 1.27195e-06 0 1.272e-06 0 1.27205e-06 0 1.2765e-06 0 1.2766e-06 1 1.2779e-06 1 1.27795e-06 0 1.278e-06 0 1.27805e-06 0 1.2825e-06 0 1.2826e-06 1 1.2839e-06 1 1.28395e-06 0 1.284e-06 0 1.28405e-06 0 1.2885e-06 0 1.2886e-06 1 1.2899e-06 1 1.28995e-06 0 1.29e-06 0 1.29005e-06 0 1.2945e-06 0 1.2946e-06 1 1.2959e-06 1 1.29595e-06 0 1.296e-06 0 1.29605e-06 0 1.3005e-06 0 1.3006e-06 1 1.3019e-06 1 1.30195e-06 0 1.302e-06 0 1.30205e-06 0 1.3065e-06 0 1.3066e-06 1 1.3079e-06 1 1.30795e-06 0 1.308e-06 0 1.30805e-06 0 1.3125e-06 0 1.3126e-06 1 1.3139e-06 1 1.31395e-06 0 1.314e-06 0 1.31405e-06 0 1.3185e-06 0 1.3186e-06 1 1.3199e-06 1 1.31995e-06 0 1.32e-06 0 1.32005e-06 0 1.3245e-06 0 1.3246e-06 1 1.3259e-06 1 1.32595e-06 0 1.326e-06 0 1.32605e-06 0 1.3305e-06 0 1.3306e-06 1 1.3319e-06 1 1.33195e-06 0 1.332e-06 0 1.33205e-06 0 1.3365e-06 0 1.3366e-06 1 1.33790000000001e-06 1 1.33795e-06 0 1.33800000000001e-06 0 1.33805e-06 0 1.3425e-06 0 1.3426e-06 1 1.34390000000001e-06 1 1.34395e-06 0 1.34400000000001e-06 0 1.34405e-06 0 1.3485e-06 0 1.3486e-06 1 1.34990000000001e-06 1 1.34995e-06 0 1.35000000000001e-06 0 1.35005e-06 0 1.3545e-06 0 1.3546e-06 1 1.35590000000001e-06 1 1.35595e-06 0 1.35600000000001e-06 0 1.35605e-06 0 1.36050000000001e-06 0 1.36060000000001e-06 1 1.36190000000001e-06 1 1.36195000000001e-06 0 1.36200000000001e-06 0 1.36205000000001e-06 0 1.36650000000001e-06 0 1.36660000000001e-06 1 1.36790000000001e-06 1 1.36795000000001e-06 0 1.36800000000001e-06 0 1.36805000000001e-06 0 1.37250000000001e-06 0 1.37260000000001e-06 1 1.37390000000001e-06 1 1.37395000000001e-06 0 1.37400000000001e-06 0 1.37405000000001e-06 0 1.37850000000001e-06 0 1.37860000000001e-06 1 1.37990000000001e-06 1 1.37995000000001e-06 0 1.38000000000001e-06 0 1.38005000000001e-06 0 1.38450000000001e-06 0 1.38460000000001e-06 1 1.38590000000001e-06 1 1.38595000000001e-06 0 1.38600000000001e-06 0 1.38605000000001e-06 0 1.39050000000001e-06 0 1.39060000000001e-06 1 1.39190000000001e-06 1 1.39195000000001e-06 0 1.39200000000001e-06 0 1.39205000000001e-06 0 1.39650000000001e-06 0 1.39660000000001e-06 1 1.39790000000001e-06 1 1.39795000000001e-06 0 1.39800000000001e-06 0 1.39805000000001e-06 0 1.40250000000001e-06 0 1.40260000000001e-06 1 1.40390000000001e-06 1 1.40395000000001e-06 0 1.40400000000001e-06 0 1.40405000000001e-06 0 1.40850000000001e-06 0 1.40860000000001e-06 1 1.40990000000001e-06 1 1.40995000000001e-06 0 1.41000000000001e-06 0 1.41005000000001e-06 0 1.41450000000001e-06 0 1.41460000000001e-06 1 1.41590000000001e-06 1 1.41595000000001e-06 0 1.41600000000001e-06 0 1.41605000000001e-06 0 1.42050000000001e-06 0 1.42060000000001e-06 1 1.42190000000001e-06 1 1.42195000000001e-06 0 1.42200000000001e-06 0 1.42205000000001e-06 0 1.42650000000001e-06 0 1.42660000000001e-06 1 1.42790000000001e-06 1 1.42795000000001e-06 0 1.42800000000001e-06 0 1.42805000000001e-06 0 1.43250000000001e-06 0 1.43260000000001e-06 1 1.43390000000001e-06 1 1.43395000000001e-06 0 1.43400000000001e-06 0 1.43405000000001e-06 0 1.43850000000001e-06 0 1.43860000000001e-06 1 1.43990000000001e-06 1 1.43995000000001e-06 0 1.44000000000001e-06 0 1.44005000000001e-06 0 1.44450000000001e-06 0 1.44460000000001e-06 1 1.44590000000001e-06 1 1.44595000000001e-06 0 1.44600000000001e-06 0 1.44605000000001e-06 0 1.45050000000001e-06 0 1.45060000000001e-06 1 1.45190000000001e-06 1 1.45195000000001e-06 0 1.45200000000001e-06 0 1.45205000000001e-06 0 1.45650000000001e-06 0 1.45660000000001e-06 1 1.45790000000001e-06 1 1.45795000000001e-06 0 1.45800000000001e-06 0 1.45805000000001e-06 0 1.46250000000001e-06 0 1.46260000000001e-06 1 1.46390000000001e-06 1 1.46395000000001e-06 0 1.46400000000001e-06 0 1.46405000000001e-06 0 1.46850000000001e-06 0 1.46860000000001e-06 1 1.46990000000001e-06 1 1.46995000000001e-06 0 1.47000000000001e-06 0 1.47005000000001e-06 0 1.47450000000001e-06 0 1.47460000000001e-06 1 1.47590000000001e-06 1 1.47595000000001e-06 0 1.47600000000001e-06 0 1.47605000000001e-06 0 1.48050000000001e-06 0 1.48060000000001e-06 1 1.48190000000001e-06 1 1.48195000000001e-06 0 1.48200000000001e-06 0 1.48205000000001e-06 0 1.48650000000001e-06 0 1.48660000000001e-06 1 1.48790000000001e-06 1 1.48795000000001e-06 0 1.48800000000001e-06 0 1.48805000000001e-06 0 1.49250000000001e-06 0 1.49260000000001e-06 1 1.49390000000001e-06 1 1.49395000000001e-06 0 1.49400000000001e-06 0 1.49405000000001e-06 0 1.49850000000001e-06 0 1.49860000000001e-06 1 1.49990000000001e-06 1 1.49995000000001e-06 0 1.50000000000001e-06 0 1.50005000000001e-06 0 1.50450000000001e-06 0 1.50460000000001e-06 1 1.50590000000001e-06 1 1.50595000000001e-06 0 1.50600000000001e-06 0 1.50605000000001e-06 0 1.51050000000001e-06 0 1.51060000000001e-06 1 1.51190000000001e-06 1 1.51195000000001e-06 0 1.51200000000001e-06 0 1.51205000000001e-06 0 1.51650000000001e-06 0 1.51660000000001e-06 1 1.51790000000001e-06 1 1.51795000000001e-06 0 1.51800000000001e-06 0 1.51805000000001e-06 0 1.52250000000001e-06 0 1.52260000000001e-06 1 1.52390000000001e-06 1 1.52395000000001e-06 0 1.52400000000001e-06 0 1.52405000000001e-06 0 1.52850000000001e-06 0 1.52860000000001e-06 1 1.52990000000001e-06 1 1.52995000000001e-06 0 1.53000000000001e-06 0 1.53005000000001e-06 0 1.53450000000001e-06 0 1.53460000000001e-06 1 1.53590000000001e-06 1 1.53595000000001e-06 0 1.53600000000001e-06 0 1.53605000000001e-06 0 1.54050000000001e-06 0 1.54060000000001e-06 1 1.54190000000001e-06 1 1.54195000000001e-06 0 1.54200000000001e-06 0 1.54205000000001e-06 0 1.54650000000001e-06 0 1.54660000000001e-06 1 1.54790000000001e-06 1 1.54795000000001e-06 0 1.54800000000001e-06 0 1.54805000000001e-06 0 1.55250000000001e-06 0 1.55260000000001e-06 1 1.55390000000001e-06 1 1.55395000000001e-06 0 1.55400000000001e-06 0 1.55405000000001e-06 0 1.55850000000001e-06 0 1.55860000000001e-06 1 1.55990000000001e-06 1 1.55995000000001e-06 0 1.56000000000001e-06 0 1.56005000000001e-06 0 1.56450000000001e-06 0 1.56460000000001e-06 1 1.56590000000001e-06 1 1.56595000000001e-06 0 1.56600000000001e-06 0 1.56605000000001e-06 0 1.57050000000001e-06 0 1.57060000000001e-06 1 1.57190000000001e-06 1 1.57195000000001e-06 0 1.57200000000001e-06 0 1.57205000000001e-06 0 1.57650000000001e-06 0 1.57660000000001e-06 1 1.57790000000001e-06 1 1.57795000000001e-06 0 1.57800000000001e-06 0 1.57805000000001e-06 0 1.58250000000001e-06 0 1.58260000000001e-06 1 1.58390000000001e-06 1 1.58395000000001e-06 0 1.58400000000001e-06 0 1.58405000000001e-06 0 1.58850000000001e-06 0 1.58860000000001e-06 1 1.58990000000001e-06 1 1.58995000000001e-06 0 1.59000000000001e-06 0 1.59005000000001e-06 0 1.59450000000001e-06 0 1.59460000000001e-06 1 1.59590000000001e-06 1 1.59595000000001e-06 0 1.59600000000001e-06 0 1.59605000000001e-06 0 1.60050000000001e-06 0 1.60060000000001e-06 1 1.60190000000001e-06 1 1.60195000000001e-06 0 1.60200000000001e-06 0 1.60205000000001e-06 0 1.60650000000001e-06 0 1.60660000000001e-06 1 1.60790000000001e-06 1 1.60795000000001e-06 0 1.60800000000001e-06 0 1.60805000000001e-06 0 1.61250000000001e-06 0 1.61260000000001e-06 1 1.61390000000001e-06 1 1.61395000000001e-06 0 1.61400000000001e-06 0 1.61405000000001e-06 0 1.61850000000001e-06 0 1.61860000000001e-06 1 1.61990000000001e-06 1 1.61995000000001e-06 0 1.62000000000001e-06 0 1.62005000000001e-06 0 1.62450000000001e-06 0 1.62460000000001e-06 1 1.62590000000001e-06 1 1.62595000000001e-06 0 1.62600000000001e-06 0 1.62605000000001e-06 0 1.63050000000001e-06 0 1.63060000000001e-06 1 1.63190000000001e-06 1 1.63195000000001e-06 0 1.63200000000001e-06 0 1.63205000000001e-06 0 1.63650000000001e-06 0 1.63660000000001e-06 1 1.63790000000001e-06 1 1.63795000000001e-06 0 1.63800000000001e-06 0 1.63805000000001e-06 0 1.64250000000001e-06 0 1.64260000000001e-06 1 1.64390000000001e-06 1 1.64395000000001e-06 0 1.64400000000001e-06 0 1.64405000000001e-06 0 1.64850000000001e-06 0 1.64860000000001e-06 1 1.64990000000001e-06 1 1.64995000000001e-06 0 1.65000000000001e-06 0 1.65005000000001e-06 0 1.65450000000001e-06 0 1.65460000000001e-06 1 1.65590000000001e-06 1 1.65595000000001e-06 0 1.65600000000001e-06 0 1.65605000000001e-06 0 1.66050000000001e-06 0 1.66060000000001e-06 1 1.66190000000001e-06 1 1.66195000000001e-06 0 1.66200000000001e-06 0 1.66205000000001e-06 0 1.66650000000001e-06 0 1.66660000000001e-06 1 1.66790000000001e-06 1 1.66795000000001e-06 0 1.66800000000001e-06 0 1.66805000000001e-06 0 1.67250000000001e-06 0 1.67260000000001e-06 1 1.67390000000001e-06 1 1.67395000000001e-06 0 1.67400000000001e-06 0 1.67405000000001e-06 0 1.67850000000001e-06 0 1.67860000000001e-06 1 1.67990000000001e-06 1 1.67995000000001e-06 0 1.68000000000001e-06 0 1.68005000000001e-06 0 1.68450000000001e-06 0 1.68460000000001e-06 1 1.68590000000001e-06 1 1.68595000000001e-06 0 1.68600000000001e-06 0 1.68605000000001e-06 0 1.69050000000001e-06 0 1.69060000000001e-06 1 1.69190000000001e-06 1 1.69195000000001e-06 0 1.69200000000001e-06 0 1.69205000000001e-06 0 1.69650000000001e-06 0 1.69660000000001e-06 1 1.69790000000001e-06 1 1.69795000000001e-06 0 1.69800000000001e-06 0 1.69805000000001e-06 0 1.70250000000001e-06 0 1.70260000000001e-06 1 1.70390000000001e-06 1 1.70395000000001e-06 0 1.70400000000001e-06 0 1.70405000000001e-06 0 1.70850000000001e-06 0 1.70860000000001e-06 1 1.70990000000001e-06 1 1.70995000000001e-06 0 1.71000000000001e-06 0 1.71005000000001e-06 0 1.71450000000001e-06 0 1.71460000000001e-06 1 1.71590000000001e-06 1 1.71595000000001e-06 0 1.71600000000001e-06 0 1.71605000000001e-06 0 1.72050000000001e-06 0 1.72060000000001e-06 1 1.72190000000001e-06 1 1.72195000000001e-06 0 1.72200000000001e-06 0 1.72205000000001e-06 0 1.72650000000001e-06 0 1.72660000000001e-06 1 1.72790000000001e-06 1 1.72795000000001e-06 0 1.72800000000001e-06 0 1.72805000000001e-06 0 1.73250000000001e-06 0 1.73260000000001e-06 1 1.73390000000001e-06 1 1.73395000000001e-06 0 1.73400000000001e-06 0 1.73405000000001e-06 0 1.73850000000001e-06 0 1.73860000000001e-06 1 1.73990000000001e-06 1 1.73995000000001e-06 0 1.74000000000001e-06 0 1.74005000000001e-06 0 1.74450000000001e-06 0 1.74460000000001e-06 1 1.74590000000001e-06 1 1.74595000000001e-06 0 1.74600000000001e-06 0 1.74605000000001e-06 0 1.75050000000001e-06 0 1.75060000000001e-06 1 1.75190000000001e-06 1 1.75195000000001e-06 0 1.75200000000001e-06 0 1.75205000000001e-06 0 1.75650000000001e-06 0 1.75660000000001e-06 1 1.75790000000001e-06 1 1.75795000000001e-06 0 1.75800000000001e-06 0 1.75805000000001e-06 0 1.76250000000001e-06 0 1.76260000000001e-06 1 1.76390000000001e-06 1 1.76395000000001e-06 0 1.76400000000001e-06 0 1.76405000000001e-06 0 1.76850000000001e-06 0 1.76860000000001e-06 1 1.76990000000001e-06 1 1.76995000000001e-06 0 1.77000000000001e-06 0 1.77005000000001e-06 0 1.77450000000001e-06 0 1.77460000000001e-06 1 1.77590000000001e-06 1 1.77595000000001e-06 0 1.77600000000001e-06 0 1.77605000000001e-06 0 1.78050000000001e-06 0 1.78060000000001e-06 1 1.78190000000001e-06 1 1.78195000000001e-06 0 1.78200000000001e-06 0 1.78205000000001e-06 0 1.78650000000001e-06 0 1.78660000000001e-06 1 1.78790000000001e-06 1 1.78795000000001e-06 0 1.78800000000001e-06 0 1.78805000000001e-06 0 1.79250000000001e-06 0 1.79260000000001e-06 1 1.79390000000001e-06 1 1.79395000000001e-06 0 1.79400000000001e-06 0 1.79405000000001e-06 0 1.79850000000001e-06 0 1.79860000000001e-06 1 1.79990000000001e-06 1 1.79995000000001e-06 0 1.80000000000001e-06 0 1.80005000000001e-06 0 1.80450000000001e-06 0 1.80460000000001e-06 1 1.80590000000001e-06 1 1.80595000000001e-06 0 1.80600000000001e-06 0 1.80605000000001e-06 0 1.81050000000001e-06 0 1.81060000000001e-06 1 1.81190000000001e-06 1 1.81195000000001e-06 0 1.81200000000001e-06 0 1.81205000000001e-06 0 1.81650000000001e-06 0 1.81660000000001e-06 1 1.81790000000001e-06 1 1.81795000000001e-06 0 1.81800000000001e-06 0 1.81805000000001e-06 0 1.82250000000001e-06 0 1.82260000000001e-06 1 1.82390000000001e-06 1 1.82395000000001e-06 0 1.82400000000001e-06 0 1.82405000000001e-06 0 1.82850000000001e-06 0 1.82860000000001e-06 1 1.82990000000001e-06 1 1.82995000000001e-06 0 1.83000000000001e-06 0 1.83005000000001e-06 0 1.83450000000001e-06 0 1.83460000000001e-06 1 1.83590000000001e-06 1 1.83595000000001e-06 0 1.83600000000001e-06 0 1.83605000000001e-06 0 1.84050000000001e-06 0 1.84060000000001e-06 1 1.84190000000001e-06 1 1.84195000000001e-06 0 1.84200000000001e-06 0 1.84205000000001e-06 0 1.84650000000001e-06 0 1.84660000000001e-06 1 1.84790000000001e-06 1 1.84795000000001e-06 0 1.84800000000001e-06 0 1.84805000000001e-06 0 1.85250000000001e-06 0 1.85260000000001e-06 1 1.85390000000001e-06 1 1.85395000000001e-06 0 1.85400000000001e-06 0 1.85405000000001e-06 0 1.85850000000001e-06 0 1.85860000000001e-06 1 1.85990000000001e-06 1 1.85995000000001e-06 0 1.86000000000001e-06 0 1.86005000000001e-06 0 1.86450000000001e-06 0 1.86460000000001e-06 1 1.86590000000001e-06 1 1.86595000000001e-06 0 1.86600000000001e-06 0 1.86605000000001e-06 0 1.87050000000001e-06 0 1.87060000000001e-06 1 1.87190000000001e-06 1 1.87195000000001e-06 0 1.87200000000001e-06 0 1.87205000000001e-06 0 1.87650000000001e-06 0 1.87660000000001e-06 1 1.87790000000001e-06 1 1.87795000000001e-06 0 1.87800000000001e-06 0 1.87805000000001e-06 0 1.88250000000001e-06 0 1.88260000000001e-06 1 1.88390000000001e-06 1 1.88395000000001e-06 0 1.88400000000001e-06 0 1.88405000000001e-06 0 1.88850000000001e-06 0 1.88860000000001e-06 1 1.88990000000001e-06 1 1.88995000000001e-06 0 1.89000000000001e-06 0 1.89005000000001e-06 0 1.89450000000001e-06 0 1.89460000000001e-06 1 1.89590000000001e-06 1 1.89595000000001e-06 0 1.89600000000001e-06 0 1.89605000000001e-06 0 1.90050000000001e-06 0 1.90060000000001e-06 1 1.90190000000001e-06 1 1.90195000000001e-06 0 1.90200000000001e-06 0 1.90205000000001e-06 0 1.90650000000001e-06 0 1.90660000000001e-06 1 1.90790000000001e-06 1 1.90795000000001e-06 0 1.90800000000001e-06 0 1.90805000000001e-06 0 1.91250000000001e-06 0 1.91260000000001e-06 1 1.91390000000001e-06 1 1.91395000000001e-06 0 1.91400000000001e-06 0 1.91405000000001e-06 0 1.91850000000001e-06 0 1.91860000000001e-06 1 1.91990000000001e-06 1 1.91995000000001e-06 0 1.92000000000001e-06 0 1.92005000000001e-06 0 1.92450000000001e-06 0 1.92460000000001e-06 1 1.92590000000001e-06 1 1.92595000000001e-06 0 1.92600000000001e-06 0 1.92605000000001e-06 0 1.93050000000001e-06 0 1.93060000000001e-06 1 1.93190000000001e-06 1 1.93195000000001e-06 0 1.93200000000001e-06 0 1.93205000000001e-06 0 1.93650000000001e-06 0 1.93660000000001e-06 1 1.93790000000001e-06 1 1.93795000000001e-06 0 1.93800000000001e-06 0 1.93805000000001e-06 0 1.94250000000001e-06 0 1.94260000000001e-06 1 1.94390000000001e-06 1 1.94395000000001e-06 0 1.94400000000001e-06 0 1.94405000000001e-06 0 1.94850000000001e-06 0 1.94860000000001e-06 1 1.94990000000001e-06 1 1.94995000000001e-06 0 1.95000000000001e-06 0 1.95005000000001e-06 0 1.95450000000001e-06 0 1.95460000000001e-06 1 1.95590000000001e-06 1 1.95595000000001e-06 0 1.95600000000001e-06 0 1.95605000000001e-06 0 1.96050000000001e-06 0 1.96060000000001e-06 1 1.96190000000001e-06 1 1.96195000000001e-06 0 1.96200000000001e-06 0 1.96205000000001e-06 0 1.96650000000001e-06 0 1.96660000000001e-06 1 1.96790000000001e-06 1 1.96795000000001e-06 0 1.96800000000001e-06 0 1.96805000000001e-06 0 1.97250000000001e-06 0 1.97260000000001e-06 1 1.97390000000001e-06 1 1.97395000000001e-06 0 1.97400000000001e-06 0 1.97405000000001e-06 0 1.97850000000001e-06 0 1.97860000000001e-06 1 1.97990000000001e-06 1 1.97995000000001e-06 0 1.98000000000001e-06 0 1.98005000000001e-06 0 1.98450000000001e-06 0 1.98460000000001e-06 1 1.98590000000001e-06 1 1.98595000000001e-06 0 1.98600000000001e-06 0 1.98605000000001e-06 0 1.99050000000001e-06 0 1.99060000000001e-06 1 1.99190000000001e-06 1 1.99195000000001e-06 0 1.99200000000001e-06 0 1.99205000000001e-06 0 1.99650000000001e-06 0 1.99660000000001e-06 1 1.99790000000001e-06 1 1.99795000000001e-06 0 1.99800000000001e-06 0 1.99805000000001e-06 0 2.00250000000001e-06 0 2.00260000000001e-06 1 2.00390000000001e-06 1 2.00395000000001e-06 0 2.00400000000001e-06 0 2.00405000000001e-06 0 2.00850000000001e-06 0 2.00860000000001e-06 1 2.00990000000001e-06 1 2.00995000000001e-06 0 2.01000000000001e-06 0 2.01005000000001e-06 0 2.01450000000001e-06 0 2.01460000000001e-06 1 2.01590000000001e-06 1 2.01595000000001e-06 0 2.01600000000001e-06 0 2.01605000000001e-06 0 2.02050000000001e-06 0 2.02060000000001e-06 1 2.02190000000001e-06 1 2.02195000000001e-06 0 2.02200000000001e-06 0 2.02205000000001e-06 0 2.02650000000001e-06 0 2.02660000000001e-06 1 2.02790000000001e-06 1 2.02795000000001e-06 0 2.02800000000001e-06 0 2.02805000000001e-06 0 2.03250000000001e-06 0 2.03260000000001e-06 1 2.03390000000001e-06 1 2.03395000000001e-06 0 2.03400000000001e-06 0 2.03405000000001e-06 0 2.03850000000001e-06 0 2.03860000000001e-06 1 2.03990000000001e-06 1 2.03995000000001e-06 0 2.04000000000001e-06 0 2.04005000000001e-06 0 2.04450000000001e-06 0 2.04460000000001e-06 1 2.04590000000001e-06 1 2.04595000000001e-06 0 2.04600000000001e-06 0 2.04605000000001e-06 0 2.05050000000001e-06 0 2.05060000000001e-06 1 2.05190000000001e-06 1 2.05195000000001e-06 0 2.05200000000001e-06 0 2.05205000000001e-06 0 2.05650000000001e-06 0 2.05660000000001e-06 1 2.05790000000001e-06 1 2.05795000000001e-06 0 2.05800000000001e-06 0 2.05805000000001e-06 0 2.06250000000001e-06 0 2.06260000000001e-06 1 2.06390000000001e-06 1 2.06395000000001e-06 0 2.06400000000001e-06 0 2.06405000000001e-06 0 2.06850000000001e-06 0 2.06860000000001e-06 1 2.06990000000001e-06 1 2.06995000000001e-06 0 2.07000000000001e-06 0 2.07005000000001e-06 0 2.07450000000001e-06 0 2.07460000000001e-06 1 2.07590000000001e-06 1 2.07595000000001e-06 0 2.07600000000001e-06 0 2.07605000000001e-06 0 2.08050000000001e-06 0 2.08060000000001e-06 1 2.08190000000001e-06 1 2.08195000000001e-06 0 2.08200000000001e-06 0 2.08205000000001e-06 0 2.08650000000001e-06 0 2.08660000000001e-06 1 2.08790000000001e-06 1 2.08795000000001e-06 0 2.08800000000001e-06 0 2.08805000000001e-06 0 2.09250000000001e-06 0 2.09260000000001e-06 1 2.09390000000001e-06 1 2.09395000000001e-06 0 2.09400000000001e-06 0 2.09405000000001e-06 0 2.09850000000001e-06 0 2.09860000000001e-06 1 2.09990000000001e-06 1 2.09995000000001e-06 0 2.10000000000001e-06 0 2.10005000000001e-06 0 2.10450000000001e-06 0 2.10460000000001e-06 1 2.10590000000001e-06 1 2.10595000000001e-06 0 2.10600000000001e-06 0 2.10605000000001e-06 0 2.11050000000001e-06 0 2.11060000000001e-06 1 2.11190000000001e-06 1 2.11195000000001e-06 0 2.11200000000001e-06 0 2.11205000000001e-06 0 2.11650000000001e-06 0 2.11660000000001e-06 1 2.11790000000001e-06 1 2.11795000000001e-06 0 2.11800000000001e-06 0 2.11805000000001e-06 0 2.12250000000001e-06 0 2.12260000000001e-06 1 2.12390000000001e-06 1 2.12395000000001e-06 0 2.12400000000001e-06 0 2.12405000000001e-06 0 2.12850000000001e-06 0 2.12860000000001e-06 1 2.12990000000001e-06 1 2.12995000000001e-06 0 2.13000000000001e-06 0 2.13005000000001e-06 0 2.13450000000001e-06 0 2.13460000000001e-06 1 2.13590000000001e-06 1 2.13595000000001e-06 0 2.13600000000001e-06 0 2.13605000000001e-06 0 2.14050000000001e-06 0 2.14060000000001e-06 1 2.14190000000001e-06 1 2.14195000000001e-06 0 2.14200000000001e-06 0 2.14205000000001e-06 0 2.14650000000001e-06 0 2.14660000000001e-06 1 2.14790000000001e-06 1 2.14795000000001e-06 0 2.14800000000001e-06 0 2.14805000000001e-06 0 2.15250000000001e-06 0 2.15260000000001e-06 1 2.15390000000001e-06 1 2.15395000000001e-06 0 2.15400000000001e-06 0 2.15405000000001e-06 0 2.15850000000001e-06 0 2.15860000000001e-06 1 2.15990000000001e-06 1 2.15995000000001e-06 0 2.16000000000001e-06 0 2.16005000000001e-06 0 2.16450000000001e-06 0 2.16460000000001e-06 1 2.16590000000001e-06 1 2.16595000000001e-06 0 2.16600000000001e-06 0 2.16605000000001e-06 0 2.17050000000001e-06 0 2.17060000000001e-06 1 2.17190000000001e-06 1 2.17195000000001e-06 0 2.17200000000001e-06 0 2.17205000000001e-06 0 2.17650000000001e-06 0 2.17660000000001e-06 1 2.17790000000001e-06 1 2.17795000000001e-06 0 2.17800000000001e-06 0 2.17805000000001e-06 0 2.18250000000001e-06 0 2.18260000000001e-06 1 2.18390000000001e-06 1 2.18395000000001e-06 0 2.18400000000001e-06 0 2.18405000000001e-06 0 2.18850000000001e-06 0 2.18860000000001e-06 1 2.18990000000001e-06 1 2.18995000000001e-06 0 2.19000000000001e-06 0 2.19005000000001e-06 0 2.19450000000001e-06 0 2.19460000000001e-06 1 2.19590000000001e-06 1 2.19595000000001e-06 0 2.19600000000001e-06 0 2.19605000000001e-06 0 2.20050000000001e-06 0 2.20060000000001e-06 1 2.20190000000001e-06 1 2.20195000000001e-06 0 2.20200000000001e-06 0 2.20205000000001e-06 0 2.20650000000001e-06 0 2.20660000000001e-06 1 2.20790000000001e-06 1 2.20795000000001e-06 0 2.20800000000001e-06 0 2.20805000000001e-06 0 2.21250000000001e-06 0 2.21260000000001e-06 1 2.21390000000001e-06 1 2.21395000000001e-06 0 2.21400000000001e-06 0 2.21405000000001e-06 0 2.21850000000001e-06 0 2.21860000000001e-06 1 2.21990000000001e-06 1 2.21995000000001e-06 0 2.22000000000001e-06 0 2.22005000000001e-06 0 2.22450000000001e-06 0 2.22460000000001e-06 1 2.22590000000001e-06 1 2.22595000000001e-06 0 2.22600000000001e-06 0 2.22605000000001e-06 0 2.23050000000001e-06 0 2.23060000000001e-06 1 2.23190000000001e-06 1 2.23195000000001e-06 0 2.23200000000001e-06 0 2.23205000000001e-06 0 2.23650000000001e-06 0 2.23660000000001e-06 1 2.23790000000001e-06 1 2.23795000000001e-06 0 2.23800000000001e-06 0 2.23805000000001e-06 0 2.24250000000001e-06 0 2.24260000000001e-06 1 2.24390000000001e-06 1 2.24395000000001e-06 0 2.24400000000001e-06 0 2.24405000000001e-06 0 2.24850000000001e-06 0 2.24860000000001e-06 1 2.24990000000001e-06 1 2.24995000000001e-06 0 2.25000000000001e-06 0 2.25005000000001e-06 0 2.25450000000001e-06 0 2.25460000000001e-06 1 2.25590000000001e-06 1 2.25595000000001e-06 0 2.25600000000001e-06 0 2.25605000000001e-06 0 2.26050000000001e-06 0 2.26060000000001e-06 1 2.26190000000001e-06 1 2.26195000000001e-06 0 2.26200000000001e-06 0 2.26205000000001e-06 0 2.26650000000001e-06 0 2.26660000000001e-06 1 2.26790000000001e-06 1 2.26795000000001e-06 0 2.26800000000001e-06 0 2.26805000000001e-06 0 2.27250000000001e-06 0 2.27260000000001e-06 1 2.27390000000001e-06 1 2.27395000000001e-06 0 2.27400000000001e-06 0 2.27405000000001e-06 0 2.27850000000001e-06 0 2.27860000000001e-06 1 2.27990000000001e-06 1 2.27995000000001e-06 0 2.28000000000001e-06 0 2.28005000000001e-06 0 2.28450000000001e-06 0 2.28460000000001e-06 1 2.28590000000001e-06 1 2.28595000000001e-06 0 2.28600000000001e-06 0 2.28605000000001e-06 0 2.29050000000001e-06 0 2.29060000000001e-06 1 2.29190000000001e-06 1 2.29195000000001e-06 0 2.29200000000001e-06 0 2.29205000000001e-06 0 2.29650000000001e-06 0 2.29660000000001e-06 1 2.29790000000001e-06 1 2.29795000000001e-06 0 2.29800000000001e-06 0 2.29805000000001e-06 0 2.30250000000001e-06 0 2.30260000000001e-06 1 2.30390000000001e-06 1 2.30395000000001e-06 0 2.30400000000001e-06 0 2.30405000000001e-06 0 2.30850000000001e-06 0 2.30860000000001e-06 1 2.30990000000001e-06 1 2.30995000000001e-06 0 2.31000000000001e-06 0 2.31005000000001e-06 0 2.31450000000001e-06 0 2.31460000000001e-06 1 2.31590000000001e-06 1 2.31595000000001e-06 0 2.31600000000001e-06 0 2.31605000000001e-06 0 2.32050000000001e-06 0 2.32060000000001e-06 1 2.32190000000001e-06 1 2.32195000000001e-06 0 2.32200000000001e-06 0 2.32205000000001e-06 0 2.32650000000001e-06 0 2.32660000000001e-06 1 2.32790000000001e-06 1 2.32795000000001e-06 0 2.32800000000001e-06 0 2.32805000000001e-06 0 2.33250000000001e-06 0 2.33260000000001e-06 1 2.33390000000001e-06 1 2.33395000000001e-06 0 2.33400000000001e-06 0 2.33405000000001e-06 0 2.33850000000001e-06 0 2.33860000000001e-06 1 2.33990000000001e-06 1 2.33995000000001e-06 0 2.34000000000001e-06 0 2.34005000000001e-06 0 2.34450000000001e-06 0 2.34460000000001e-06 1 2.34590000000001e-06 1 2.34595000000001e-06 0 2.34600000000001e-06 0 2.34605000000001e-06 0 2.35050000000001e-06 0 2.35060000000001e-06 1 2.35190000000001e-06 1 2.35195000000001e-06 0 2.35200000000001e-06 0 2.35205000000001e-06 0 2.35650000000001e-06 0 2.35660000000001e-06 1 2.35790000000001e-06 1 2.35795000000001e-06 0 2.35800000000001e-06 0 2.35805000000001e-06 0 2.36250000000001e-06 0 2.36260000000001e-06 1 2.36390000000001e-06 1 2.36395000000001e-06 0 2.36400000000001e-06 0 2.36405000000001e-06 0 2.36850000000001e-06 0 2.36860000000001e-06 1 2.36990000000001e-06 1 2.36995000000001e-06 0 2.37000000000001e-06 0 2.37005000000001e-06 0 2.37450000000001e-06 0 2.37460000000001e-06 1 2.37590000000001e-06 1 2.37595000000001e-06 0 2.37600000000001e-06 0 2.37605000000001e-06 0 2.38050000000001e-06 0 2.38060000000001e-06 1 2.38190000000001e-06 1 2.38195000000001e-06 0 2.38200000000001e-06 0 2.38205000000001e-06 0 2.38650000000001e-06 0 2.38660000000001e-06 1 2.38790000000001e-06 1 2.38795000000001e-06 0 2.38800000000001e-06 0 2.38805000000001e-06 0 2.39250000000001e-06 0 2.39260000000001e-06 1 2.39390000000001e-06 1 2.39395000000001e-06 0 2.39400000000001e-06 0 2.39405000000001e-06 0 2.39850000000001e-06 0 2.39860000000001e-06 1 2.39990000000001e-06 1 2.39995000000001e-06 0 2.40000000000001e-06 0 2.40005000000001e-06 0 2.40450000000001e-06 0 2.40460000000001e-06 1 2.40590000000001e-06 1 2.40595000000001e-06 0 2.40600000000001e-06 0 2.40605000000001e-06 0 2.41050000000001e-06 0 2.41060000000001e-06 1 2.41190000000001e-06 1 2.41195000000001e-06 0 2.41200000000001e-06 0 2.41205000000001e-06 0 2.41650000000001e-06 0 2.41660000000001e-06 1 2.41790000000001e-06 1 2.41795000000001e-06 0 2.41800000000001e-06 0 2.41805000000001e-06 0 2.42250000000001e-06 0 2.42260000000001e-06 1 2.42390000000001e-06 1 2.42395000000001e-06 0 2.42400000000001e-06 0 2.42405000000001e-06 0 2.42850000000001e-06 0 2.42860000000001e-06 1 2.42990000000001e-06 1 2.42995000000001e-06 0 2.43000000000001e-06 0 2.43005000000001e-06 0 2.43450000000001e-06 0 2.43460000000001e-06 1 2.43590000000001e-06 1 2.43595000000001e-06 0 2.43600000000001e-06 0 2.43605000000001e-06 0 2.44050000000001e-06 0 2.44060000000001e-06 1 2.44190000000001e-06 1 2.44195000000001e-06 0 2.44200000000001e-06 0 2.44205000000001e-06 0 2.44650000000001e-06 0 2.44660000000001e-06 1 2.44790000000001e-06 1 2.44795000000001e-06 0 2.44800000000001e-06 0 2.44805000000001e-06 0 2.45250000000001e-06 0 2.45260000000001e-06 1 2.45390000000001e-06 1 2.45395000000001e-06 0 2.45400000000001e-06 0 2.45405000000001e-06 0 2.45850000000001e-06 0 2.45860000000001e-06 1 2.45990000000001e-06 1 2.45995000000001e-06 0 2.46000000000001e-06 0 2.46005000000001e-06 0 2.46450000000001e-06 0 2.46460000000001e-06 1 2.46590000000001e-06 1 2.46595000000001e-06 0 2.46600000000001e-06 0 2.46605000000001e-06 0 2.47050000000001e-06 0 2.47060000000001e-06 1 2.47190000000001e-06 1 2.47195000000001e-06 0 2.47200000000001e-06 0 2.47205000000001e-06 0 2.47650000000001e-06 0 2.47660000000001e-06 1 2.47790000000001e-06 1 2.47795000000001e-06 0 2.47800000000001e-06 0 2.47805000000001e-06 0 2.48250000000001e-06 0 2.48260000000001e-06 1 2.48390000000001e-06 1 2.48395000000001e-06 0 2.48400000000001e-06 0 2.48405000000001e-06 0 2.48850000000001e-06 0 2.48860000000001e-06 1 2.48990000000001e-06 1 2.48995000000001e-06 0 2.49000000000001e-06 0 2.49005000000001e-06 0 2.49450000000001e-06 0 2.49460000000001e-06 1 2.49590000000001e-06 1 2.49595000000001e-06 0 2.49600000000001e-06 0 2.49605000000001e-06 0 2.50050000000001e-06 0 2.50060000000001e-06 1 2.50190000000001e-06 1 2.50195000000001e-06 0 2.50200000000001e-06 0 2.50205000000001e-06 0 2.50650000000001e-06 0 2.50660000000001e-06 1 2.50790000000001e-06 1 2.50795000000001e-06 0 2.50800000000001e-06 0 2.50805000000001e-06 0 2.51250000000001e-06 0 2.51260000000001e-06 1 2.51390000000001e-06 1 2.51395000000001e-06 0 2.51400000000001e-06 0 2.51405000000001e-06 0 2.51850000000001e-06 0 2.51860000000001e-06 1 2.51990000000001e-06 1 2.51995000000001e-06 0 2.52000000000001e-06 0 2.52005000000001e-06 0 2.52450000000001e-06 0 2.52460000000001e-06 1 2.52590000000001e-06 1 2.52595000000001e-06 0 2.52600000000001e-06 0 2.52605000000001e-06 0 2.53050000000001e-06 0 2.53060000000001e-06 1 2.53190000000001e-06 1 2.53195000000001e-06 0 2.53200000000001e-06 0 2.53205000000001e-06 0 2.53650000000001e-06 0 2.53660000000001e-06 1 2.53790000000001e-06 1 2.53795000000001e-06 0 2.53800000000001e-06 0 2.53805000000001e-06 0 2.54250000000001e-06 0 2.54260000000001e-06 1 2.54390000000001e-06 1 2.54395000000001e-06 0 2.54400000000001e-06 0 2.54405000000001e-06 0 2.54850000000001e-06 0 2.54860000000001e-06 1 2.54990000000001e-06 1 2.54995000000001e-06 0 2.55000000000001e-06 0 2.55005000000001e-06 0 2.55450000000001e-06 0 2.55460000000001e-06 1 2.55590000000001e-06 1 2.55595000000001e-06 0 2.55600000000001e-06 0 2.55605000000001e-06 0 2.56050000000001e-06 0 2.56060000000001e-06 1 2.56190000000001e-06 1 2.56195000000001e-06 0 2.56200000000001e-06 0 2.56205000000001e-06 0 2.56650000000001e-06 0 2.56660000000001e-06 1 2.56790000000001e-06 1 2.56795000000001e-06 0 2.56800000000001e-06 0 2.56805000000001e-06 0 2.57250000000001e-06 0 2.57260000000001e-06 1 2.57390000000001e-06 1 2.57395000000001e-06 0 2.57400000000001e-06 0 2.57405000000001e-06 0 2.57850000000001e-06 0 2.57860000000001e-06 1 2.57990000000001e-06 1 2.57995000000001e-06 0 2.58000000000001e-06 0 2.58005000000001e-06 0 2.58450000000001e-06 0 2.58460000000001e-06 1 2.58590000000001e-06 1 2.58595000000001e-06 0 2.58600000000001e-06 0 2.58605000000001e-06 0 2.59050000000001e-06 0 2.59060000000001e-06 1 2.59190000000001e-06 1 2.59195000000001e-06 0 2.59200000000001e-06 0 2.59205000000001e-06 0 2.59650000000001e-06 0 2.59660000000001e-06 1 2.59790000000001e-06 1 2.59795000000001e-06 0 2.59800000000001e-06 0 2.59805000000001e-06 0 2.60250000000001e-06 0 2.60260000000001e-06 1 2.60390000000001e-06 1 2.60395000000001e-06 0 2.60400000000001e-06 0 2.60405000000001e-06 0 2.60850000000001e-06 0 2.60860000000001e-06 1 2.60990000000001e-06 1 2.60995000000001e-06 0 2.61000000000001e-06 0 2.61005000000001e-06 0 2.61450000000001e-06 0 2.61460000000001e-06 1 2.61590000000001e-06 1 2.61595000000001e-06 0 2.61600000000001e-06 0 2.61605000000001e-06 0 2.62050000000001e-06 0 2.62060000000001e-06 1 2.62190000000001e-06 1 2.62195000000001e-06 0 2.62200000000001e-06 0 2.62205000000001e-06 0 2.62650000000001e-06 0 2.62660000000001e-06 1 2.62790000000001e-06 1 2.62795000000001e-06 0 2.62800000000001e-06 0 2.62805000000001e-06 0 2.63250000000001e-06 0 2.63260000000001e-06 1 2.63390000000001e-06 1 2.63395000000001e-06 0 2.63400000000001e-06 0 2.63405000000001e-06 0 2.63850000000001e-06 0 2.63860000000001e-06 1 2.63990000000001e-06 1 2.63995000000001e-06 0 2.64000000000001e-06 0 2.64005000000001e-06 0 2.64450000000001e-06 0 2.64460000000001e-06 1 2.64590000000001e-06 1 2.64595000000001e-06 0 2.64600000000001e-06 0 2.64605000000001e-06 0 2.65050000000001e-06 0 2.65060000000001e-06 1 2.65190000000001e-06 1 2.65195000000001e-06 0 2.65200000000001e-06 0 2.65205000000001e-06 0 2.65650000000001e-06 0 2.65660000000001e-06 1 2.65790000000001e-06 1 2.65795000000001e-06 0 2.65800000000001e-06 0 2.65805000000001e-06 0 2.66250000000001e-06 0 2.66260000000001e-06 1 2.66390000000001e-06 1 2.66395000000001e-06 0 2.66400000000001e-06 0 2.66405000000001e-06 0 2.66850000000001e-06 0 2.66860000000001e-06 1 2.66990000000001e-06 1 2.66995000000001e-06 0 2.67000000000001e-06 0 2.67005000000001e-06 0 2.67450000000001e-06 0 2.67460000000001e-06 1 2.67590000000001e-06 1 2.67595000000001e-06 0 2.67600000000001e-06 0 2.67605000000001e-06 0 2.68050000000001e-06 0 2.68060000000001e-06 1 2.68190000000001e-06 1 2.68195000000001e-06 0 2.68200000000001e-06 0 2.68205000000001e-06 0 2.68650000000001e-06 0 2.68660000000001e-06 1 2.68790000000001e-06 1 2.68795000000001e-06 0 2.68800000000001e-06 0 2.68805000000001e-06 0 2.69250000000001e-06 0 2.69260000000001e-06 1 2.69390000000001e-06 1 2.69395000000001e-06 0 2.69400000000001e-06 0 2.69405000000001e-06 0 2.69850000000001e-06 0 2.69860000000001e-06 1 2.69990000000001e-06 1 2.69995000000001e-06 0 2.70000000000001e-06 0 2.70005000000001e-06 0 2.70450000000001e-06 0 2.70460000000001e-06 1 2.70590000000001e-06 1 2.70595000000001e-06 0 2.70600000000001e-06 0 2.70605000000001e-06 0 2.71050000000001e-06 0 2.71060000000001e-06 1 2.71190000000001e-06 1 2.71195000000001e-06 0 2.71200000000001e-06 0 2.71205000000001e-06 0 2.71650000000001e-06 0 2.71660000000001e-06 1 2.71790000000001e-06 1 2.71795000000001e-06 0 2.71800000000001e-06 0 2.71805000000001e-06 0 2.72250000000001e-06 0 2.72260000000001e-06 1 2.72390000000001e-06 1 2.72395000000001e-06 0 2.72400000000001e-06 0 2.72405000000001e-06 0 2.72850000000001e-06 0 2.72860000000001e-06 1 2.72990000000001e-06 1 2.72995000000001e-06 0 2.73000000000001e-06 0 2.73005000000001e-06 0 2.73450000000001e-06 0 2.73460000000001e-06 1 2.73590000000001e-06 1 2.73595000000001e-06 0 2.73600000000001e-06 0 2.73605000000001e-06 0 2.74050000000001e-06 0 2.74060000000001e-06 1 2.74190000000001e-06 1 2.74195000000001e-06 0 2.74200000000001e-06 0 2.74205000000001e-06 0 2.74650000000001e-06 0 2.74660000000001e-06 1 2.74790000000001e-06 1 2.74795000000001e-06 0 2.74800000000001e-06 0 2.74805000000001e-06 0 2.75250000000001e-06 0 2.75260000000001e-06 1 2.75390000000001e-06 1 2.75395000000001e-06 0 2.75400000000001e-06 0 2.75405000000001e-06 0 2.75850000000001e-06 0 2.75860000000001e-06 1 2.75990000000001e-06 1 2.75995000000001e-06 0 2.76000000000001e-06 0 2.76005000000001e-06 0 2.76450000000001e-06 0 2.76460000000001e-06 1 2.76590000000001e-06 1 2.76595000000001e-06 0 2.76600000000001e-06 0 2.76605000000001e-06 0 2.77050000000001e-06 0 2.77060000000001e-06 1 2.77190000000001e-06 1 2.77195000000001e-06 0 2.77200000000001e-06 0 2.77205000000001e-06 0 2.77650000000001e-06 0 2.77660000000001e-06 1 2.77790000000001e-06 1 2.77795000000001e-06 0 2.77800000000001e-06 0 2.77805000000001e-06 0 2.78250000000001e-06 0 2.78260000000001e-06 1 2.78390000000001e-06 1 2.78395000000001e-06 0 2.78400000000001e-06 0 2.78405000000001e-06 0 2.78850000000001e-06 0 2.78860000000001e-06 1 2.78990000000001e-06 1 2.78995000000001e-06 0 2.79000000000001e-06 0 2.79005000000001e-06 0 2.79450000000001e-06 0 2.79460000000001e-06 1 2.79590000000001e-06 1 2.79595000000001e-06 0 2.79600000000001e-06 0 2.79605000000001e-06 0 2.80050000000001e-06 0 2.80060000000001e-06 1 2.80190000000001e-06 1 2.80195000000001e-06 0 2.80200000000001e-06 0 2.80205000000001e-06 0 2.80650000000001e-06 0 2.80660000000001e-06 1 2.80790000000001e-06 1 2.80795000000001e-06 0 2.80800000000001e-06 0 2.80805000000001e-06 0 2.81250000000001e-06 0 2.81260000000001e-06 1 2.81390000000001e-06 1 2.81395000000001e-06 0 2.81400000000001e-06 0 2.81405000000001e-06 0 2.81850000000001e-06 0 2.81860000000001e-06 1 2.81990000000001e-06 1 2.81995000000001e-06 0 2.82000000000001e-06 0 2.82005000000001e-06 0 2.82450000000001e-06 0 2.82460000000001e-06 1 2.82590000000001e-06 1 2.82595000000001e-06 0 2.82600000000001e-06 0 2.82605000000001e-06 0 2.83050000000001e-06 0 2.83060000000001e-06 1 2.83190000000001e-06 1 2.83195000000001e-06 0 2.83200000000001e-06 0 2.83205000000001e-06 0 2.83650000000001e-06 0 2.83660000000001e-06 1 2.83790000000001e-06 1 2.83795000000001e-06 0 2.83800000000001e-06 0 2.83805000000001e-06 0 2.84250000000001e-06 0 2.84260000000001e-06 1 2.84390000000001e-06 1 2.84395000000001e-06 0 2.84400000000001e-06 0 2.84405000000001e-06 0 2.84850000000001e-06 0 2.84860000000001e-06 1 2.84990000000001e-06 1 2.84995000000001e-06 0 2.85000000000001e-06 0 2.85005000000001e-06 0 2.85450000000001e-06 0 2.85460000000001e-06 1 2.85590000000001e-06 1 2.85595000000001e-06 0 2.85600000000001e-06 0 2.85605000000001e-06 0 2.86050000000001e-06 0 2.86060000000001e-06 1 2.86190000000001e-06 1 2.86195000000001e-06 0 2.86200000000001e-06 0 2.86205000000001e-06 0 2.86650000000001e-06 0 2.86660000000001e-06 1 2.86790000000001e-06 1 2.86795000000001e-06 0 2.86800000000001e-06 0 2.86805000000001e-06 0 2.87250000000001e-06 0 2.87260000000001e-06 1 2.87390000000001e-06 1 2.87395000000001e-06 0 2.87400000000001e-06 0 2.87405000000001e-06 0 2.87850000000001e-06 0 2.87860000000001e-06 1 2.87990000000001e-06 1 2.87995000000001e-06 0 2.88000000000001e-06 0 2.88005000000001e-06 0 2.88450000000001e-06 0 2.88460000000001e-06 1 2.88590000000001e-06 1 2.88595000000001e-06 0 2.88600000000001e-06 0 2.88605000000001e-06 0 2.89050000000001e-06 0 2.89060000000001e-06 1 2.89190000000001e-06 1 2.89195000000001e-06 0 2.89200000000001e-06 0 2.89205000000001e-06 0 2.89650000000001e-06 0 2.89660000000001e-06 1 2.89790000000001e-06 1 2.89795000000001e-06 0 2.89800000000001e-06 0 2.89805000000001e-06 0 2.90250000000001e-06 0 2.90260000000001e-06 1 2.90390000000001e-06 1 2.90395000000001e-06 0 2.90400000000001e-06 0 2.90405000000001e-06 0 2.90850000000001e-06 0 2.90860000000001e-06 1 2.90990000000001e-06 1 2.90995000000001e-06 0 2.91000000000001e-06 0 2.91005000000001e-06 0 2.91450000000001e-06 0 2.91460000000001e-06 1 2.91590000000001e-06 1 2.91595000000001e-06 0 2.91600000000001e-06 0 2.91605000000001e-06 0 2.92050000000001e-06 0 2.92060000000001e-06 1 2.92190000000001e-06 1 2.92195000000001e-06 0 2.92200000000001e-06 0 2.92205000000001e-06 0 2.92650000000001e-06 0 2.92660000000001e-06 1 2.92790000000001e-06 1 2.92795000000001e-06 0 2.92800000000001e-06 0 2.92805000000001e-06 0 2.93250000000001e-06 0 2.93260000000001e-06 1 2.93390000000001e-06 1 2.93395000000001e-06 0 2.93400000000001e-06 0 2.93405000000001e-06 0 2.93850000000001e-06 0 2.93860000000001e-06 1 2.93990000000001e-06 1 2.93995000000001e-06 0 2.94000000000001e-06 0 2.94005000000001e-06 0 2.94450000000001e-06 0 2.94460000000001e-06 1 2.94590000000001e-06 1 2.94595000000001e-06 0 2.94600000000001e-06 0 2.94605000000001e-06 0 2.95050000000001e-06 0 2.95060000000001e-06 1 2.95190000000001e-06 1 2.95195000000001e-06 0 2.95200000000001e-06 0 2.95205000000001e-06 0 2.95650000000001e-06 0 2.95660000000001e-06 1 2.95790000000001e-06 1 2.95795000000001e-06 0 2.95800000000001e-06 0 2.95805000000001e-06 0 2.96250000000001e-06 0 2.96260000000001e-06 1 2.96390000000001e-06 1 2.96395000000001e-06 0 2.96400000000001e-06 0 2.96405000000001e-06 0 2.96850000000001e-06 0 2.96860000000001e-06 1 2.96990000000001e-06 1 2.96995000000001e-06 0 2.97000000000001e-06 0 2.97005000000001e-06 0 2.97450000000001e-06 0 2.97460000000001e-06 1 2.97590000000001e-06 1 2.97595000000001e-06 0 2.97600000000001e-06 0 2.97605000000001e-06 0 2.98050000000001e-06 0 2.98060000000001e-06 1 2.98190000000001e-06 1 2.98195000000001e-06 0 2.98200000000001e-06 0 2.98205000000001e-06 0 2.98650000000001e-06 0 2.98660000000001e-06 1 2.98790000000001e-06 1 2.98795000000001e-06 0 2.98800000000001e-06 0 2.98805000000001e-06 0 2.99250000000001e-06 0 2.99260000000001e-06 1 2.99390000000001e-06 1 2.99395000000001e-06 0 2.99400000000001e-06 0 2.99405000000001e-06 0 2.99850000000001e-06 0 2.99860000000001e-06 1 2.99990000000001e-06 1 2.99995000000001e-06 0 3.00000000000001e-06 0 3.00005000000001e-06 0 3.00450000000001e-06 0 3.00460000000001e-06 1 3.00590000000001e-06 1 3.00595000000001e-06 0 3.00600000000001e-06 0 3.00605000000001e-06 0 3.01050000000001e-06 0 3.01060000000001e-06 1 3.01190000000001e-06 1 3.01195000000001e-06 0 3.01200000000001e-06 0 3.01205000000001e-06 0 3.01650000000001e-06 0 3.01660000000001e-06 1 3.01790000000001e-06 1 3.01795000000001e-06 0 3.01800000000001e-06 0 3.01805000000001e-06 0 3.02250000000001e-06 0 3.02260000000001e-06 1 3.02390000000001e-06 1 3.02395000000001e-06 0 3.02400000000001e-06 0 3.02405000000001e-06 0 3.02850000000001e-06 0 3.02860000000001e-06 1 3.02990000000001e-06 1 3.02995000000001e-06 0 3.03000000000001e-06 0 3.03005000000001e-06 0 3.03450000000001e-06 0 3.03460000000001e-06 1 3.03590000000001e-06 1 3.03595000000001e-06 0 3.03600000000001e-06 0 3.03605000000001e-06 0 3.04050000000001e-06 0 3.04060000000001e-06 1 3.04190000000001e-06 1 3.04195000000001e-06 0 3.04200000000001e-06 0 3.04205000000001e-06 0 3.04650000000001e-06 0 3.04660000000001e-06 1 3.04790000000001e-06 1 3.04795000000001e-06 0 3.04800000000001e-06 0 3.04805000000001e-06 0 3.05250000000001e-06 0 3.05260000000001e-06 1 3.05390000000001e-06 1 3.05395000000001e-06 0 3.05400000000001e-06 0 3.05405000000001e-06 0 3.05850000000001e-06 0 3.05860000000001e-06 1 3.05990000000001e-06 1 3.05995000000001e-06 0 3.06000000000001e-06 0 3.06005000000001e-06 0 3.06450000000001e-06 0 3.06460000000001e-06 1 3.06590000000001e-06 1 3.06595000000001e-06 0 3.06600000000001e-06 0 3.06605000000001e-06 0 3.07050000000001e-06 0 3.07060000000001e-06 1 3.07190000000001e-06 1 3.07195000000001e-06 0 3.07740000000001e-06 0]
parameters wave_SAP = [0 1 4.5e-09 1 4.55e-09 0 6e-09 0 6.1e-09 1 1.05e-08 1 1.055e-08 0 1.2e-08 0 1.21e-08 1 1.65e-08 1 1.655e-08 0 1.8e-08 0 1.81e-08 1 2.25e-08 1 2.255e-08 0 2.4e-08 0 2.41e-08 1 2.85e-08 1 2.855e-08 0 3e-08 0 3.01e-08 1 3.45e-08 1 3.455e-08 0 3.6e-08 0 3.61e-08 1 4.05e-08 1 4.055e-08 0 4.2e-08 0 4.21e-08 1 4.65e-08 1 4.655e-08 0 4.8e-08 0 4.81e-08 1 5.25e-08 1 5.255e-08 0 5.4e-08 0 5.41e-08 1 5.85e-08 1 5.855e-08 0 6e-08 0 6.01e-08 1 6.45e-08 1 6.455e-08 0 6.6e-08 0 6.61e-08 1 7.05e-08 1 7.055e-08 0 7.2e-08 0 7.21e-08 1 7.65e-08 1 7.655e-08 0 7.8e-08 0 7.81e-08 1 8.25e-08 1 8.255e-08 0 8.4e-08 0 8.41e-08 1 8.85e-08 1 8.855e-08 0 9e-08 0 9.01e-08 1 9.45e-08 1 9.455e-08 0 9.6e-08 0 9.61e-08 1 1.005e-07 1 1.0055e-07 0 1.02e-07 0 1.021e-07 1 1.065e-07 1 1.0655e-07 0 1.08e-07 0 1.081e-07 1 1.125e-07 1 1.1255e-07 0 1.14e-07 0 1.141e-07 1 1.185e-07 1 1.1855e-07 0 1.2e-07 0 1.201e-07 1 1.245e-07 1 1.2455e-07 0 1.26e-07 0 1.261e-07 1 1.305e-07 1 1.3055e-07 0 1.32e-07 0 1.321e-07 1 1.365e-07 1 1.3655e-07 0 1.38e-07 0 1.381e-07 1 1.425e-07 1 1.4255e-07 0 1.44e-07 0 1.441e-07 1 1.485e-07 1 1.4855e-07 0 1.5e-07 0 1.501e-07 1 1.545e-07 1 1.5455e-07 0 1.56e-07 0 1.561e-07 1 1.605e-07 1 1.6055e-07 0 1.62e-07 0 1.621e-07 1 1.665e-07 1 1.6655e-07 0 1.68e-07 0 1.681e-07 1 1.725e-07 1 1.7255e-07 0 1.74e-07 0 1.741e-07 1 1.785e-07 1 1.7855e-07 0 1.8e-07 0 1.801e-07 1 1.845e-07 1 1.8455e-07 0 1.86e-07 0 1.861e-07 1 1.905e-07 1 1.9055e-07 0 1.92e-07 0 1.921e-07 1 1.965e-07 1 1.9655e-07 0 1.98e-07 0 1.981e-07 1 2.025e-07 1 2.0255e-07 0 2.04e-07 0 2.041e-07 1 2.085e-07 1 2.0855e-07 0 2.1e-07 0 2.101e-07 1 2.145e-07 1 2.1455e-07 0 2.16e-07 0 2.161e-07 1 2.205e-07 1 2.2055e-07 0 2.22e-07 0 2.221e-07 1 2.265e-07 1 2.2655e-07 0 2.28e-07 0 2.281e-07 1 2.325e-07 1 2.3255e-07 0 2.34e-07 0 2.341e-07 1 2.385e-07 1 2.3855e-07 0 2.4e-07 0 2.401e-07 1 2.445e-07 1 2.4455e-07 0 2.46e-07 0 2.461e-07 1 2.505e-07 1 2.5055e-07 0 2.52e-07 0 2.521e-07 1 2.565e-07 1 2.5655e-07 0 2.58e-07 0 2.581e-07 1 2.625e-07 1 2.6255e-07 0 2.64e-07 0 2.641e-07 1 2.685e-07 1 2.6855e-07 0 2.7e-07 0 2.701e-07 1 2.745e-07 1 2.7455e-07 0 2.76e-07 0 2.761e-07 1 2.805e-07 1 2.8055e-07 0 2.82e-07 0 2.821e-07 1 2.865e-07 1 2.8655e-07 0 2.88e-07 0 2.881e-07 1 2.925e-07 1 2.9255e-07 0 2.94e-07 0 2.941e-07 1 2.985e-07 1 2.9855e-07 0 3e-07 0 3.001e-07 1 3.045e-07 1 3.0455e-07 0 3.06e-07 0 3.061e-07 1 3.105e-07 1 3.1055e-07 0 3.12e-07 0 3.121e-07 1 3.165e-07 1 3.1655e-07 0 3.18e-07 0 3.181e-07 1 3.225e-07 1 3.2255e-07 0 3.24e-07 0 3.241e-07 1 3.285e-07 1 3.2855e-07 0 3.3e-07 0 3.301e-07 1 3.345e-07 1 3.3455e-07 0 3.36e-07 0 3.361e-07 1 3.405e-07 1 3.4055e-07 0 3.42e-07 0 3.42100000000001e-07 1 3.46500000000001e-07 1 3.46550000000001e-07 0 3.48000000000001e-07 0 3.48100000000001e-07 1 3.52500000000001e-07 1 3.52550000000001e-07 0 3.54000000000001e-07 0 3.54100000000001e-07 1 3.58500000000001e-07 1 3.58550000000001e-07 0 3.60000000000001e-07 0 3.60100000000001e-07 1 3.64500000000001e-07 1 3.64550000000001e-07 0 3.66000000000001e-07 0 3.66100000000001e-07 1 3.70500000000001e-07 1 3.70550000000001e-07 0 3.72000000000001e-07 0 3.72100000000001e-07 1 3.76500000000001e-07 1 3.76550000000001e-07 0 3.78000000000001e-07 0 3.78100000000001e-07 1 3.82500000000001e-07 1 3.82550000000001e-07 0 3.84000000000001e-07 0 3.84100000000001e-07 1 3.88500000000001e-07 1 3.88550000000001e-07 0 3.90000000000001e-07 0 3.90100000000001e-07 1 3.94500000000001e-07 1 3.94550000000001e-07 0 3.96000000000001e-07 0 3.96100000000001e-07 1 4.00500000000001e-07 1 4.00550000000001e-07 0 4.02000000000001e-07 0 4.02100000000001e-07 1 4.06500000000001e-07 1 4.06550000000001e-07 0 4.08000000000001e-07 0 4.08100000000001e-07 1 4.12500000000001e-07 1 4.12550000000001e-07 0 4.14000000000001e-07 0 4.14100000000001e-07 1 4.18500000000001e-07 1 4.18550000000001e-07 0 4.20000000000001e-07 0 4.20100000000001e-07 1 4.24500000000001e-07 1 4.24550000000001e-07 0 4.26000000000001e-07 0 4.26100000000001e-07 1 4.30500000000001e-07 1 4.30550000000001e-07 0 4.32000000000001e-07 0 4.32100000000001e-07 1 4.36500000000001e-07 1 4.36550000000001e-07 0 4.38000000000001e-07 0 4.38100000000001e-07 1 4.42500000000001e-07 1 4.42550000000001e-07 0 4.44000000000001e-07 0 4.44100000000001e-07 1 4.48500000000001e-07 1 4.48550000000001e-07 0 4.50000000000001e-07 0 4.50100000000001e-07 1 4.54500000000001e-07 1 4.54550000000001e-07 0 4.56000000000001e-07 0 4.56100000000001e-07 1 4.60500000000001e-07 1 4.60550000000001e-07 0 4.62000000000001e-07 0 4.62100000000001e-07 1 4.66500000000001e-07 1 4.66550000000001e-07 0 4.68000000000001e-07 0 4.68100000000001e-07 1 4.72500000000001e-07 1 4.72550000000001e-07 0 4.74000000000001e-07 0 4.74100000000001e-07 1 4.78500000000001e-07 1 4.78550000000001e-07 0 4.80000000000001e-07 0 4.80100000000001e-07 1 4.84500000000001e-07 1 4.84550000000001e-07 0 4.86000000000001e-07 0 4.86100000000001e-07 1 4.90500000000001e-07 1 4.90550000000001e-07 0 4.92000000000001e-07 0 4.92100000000001e-07 1 4.96500000000001e-07 1 4.96550000000001e-07 0 4.98000000000001e-07 0 4.98100000000001e-07 1 5.02500000000001e-07 1 5.02550000000001e-07 0 5.04000000000001e-07 0 5.04100000000001e-07 1 5.08500000000001e-07 1 5.08550000000001e-07 0 5.10000000000001e-07 0 5.10100000000001e-07 1 5.14500000000001e-07 1 5.14550000000001e-07 0 5.16000000000001e-07 0 5.16100000000001e-07 1 5.20500000000001e-07 1 5.20550000000001e-07 0 5.22000000000001e-07 0 5.22100000000001e-07 1 5.26500000000001e-07 1 5.26550000000001e-07 0 5.28000000000001e-07 0 5.28100000000001e-07 1 5.32500000000001e-07 1 5.32550000000001e-07 0 5.34000000000001e-07 0 5.34100000000001e-07 1 5.38500000000001e-07 1 5.38550000000001e-07 0 5.40000000000001e-07 0 5.40100000000001e-07 1 5.44500000000001e-07 1 5.44550000000001e-07 0 5.46000000000001e-07 0 5.46100000000001e-07 1 5.50500000000001e-07 1 5.50550000000001e-07 0 5.52000000000001e-07 0 5.52100000000001e-07 1 5.56500000000001e-07 1 5.56550000000001e-07 0 5.58000000000001e-07 0 5.58100000000001e-07 1 5.62500000000001e-07 1 5.62550000000002e-07 0 5.64000000000002e-07 0 5.64100000000002e-07 1 5.68500000000002e-07 1 5.68550000000002e-07 0 5.70000000000002e-07 0 5.70100000000002e-07 1 5.74500000000002e-07 1 5.74550000000002e-07 0 5.76000000000002e-07 0 5.76100000000002e-07 1 5.80500000000002e-07 1 5.80550000000002e-07 0 5.82000000000002e-07 0 5.82100000000002e-07 1 5.86500000000002e-07 1 5.86550000000002e-07 0 5.88000000000002e-07 0 5.88100000000002e-07 1 5.92500000000002e-07 1 5.92550000000002e-07 0 5.94000000000002e-07 0 5.94100000000002e-07 1 5.98500000000002e-07 1 5.98550000000002e-07 0 6.00000000000002e-07 0 6.00100000000002e-07 1 6.04500000000002e-07 1 6.04550000000002e-07 0 6.06000000000002e-07 0 6.06100000000002e-07 1 6.10500000000002e-07 1 6.10550000000002e-07 0 6.12000000000002e-07 0 6.12100000000002e-07 1 6.16500000000002e-07 1 6.16550000000002e-07 0 6.18000000000002e-07 0 6.18100000000002e-07 1 6.22500000000002e-07 1 6.22550000000002e-07 0 6.24000000000002e-07 0 6.24100000000002e-07 1 6.28500000000002e-07 1 6.28550000000002e-07 0 6.30000000000002e-07 0 6.30100000000002e-07 1 6.34500000000002e-07 1 6.34550000000002e-07 0 6.36000000000002e-07 0 6.36100000000002e-07 1 6.40500000000002e-07 1 6.40550000000002e-07 0 6.42000000000002e-07 0 6.42100000000002e-07 1 6.46500000000002e-07 1 6.46550000000002e-07 0 6.48000000000002e-07 0 6.48100000000002e-07 1 6.52500000000002e-07 1 6.52550000000002e-07 0 6.54000000000002e-07 0 6.54100000000002e-07 1 6.58500000000002e-07 1 6.58550000000002e-07 0 6.60000000000002e-07 0 6.60100000000002e-07 1 6.64500000000002e-07 1 6.64550000000002e-07 0 6.66000000000002e-07 0 6.66100000000002e-07 1 6.70500000000002e-07 1 6.70550000000002e-07 0 6.72000000000002e-07 0 6.72100000000002e-07 1 6.76500000000002e-07 1 6.76550000000002e-07 0 6.78000000000002e-07 0 6.78100000000002e-07 1 6.82500000000002e-07 1 6.82550000000002e-07 0 6.84000000000002e-07 0 6.84100000000002e-07 1 6.88500000000002e-07 1 6.88550000000002e-07 0 6.90000000000002e-07 0 6.90100000000002e-07 1 6.94500000000002e-07 1 6.94550000000002e-07 0 6.96000000000002e-07 0 6.96100000000002e-07 1 7.00500000000002e-07 1 7.00550000000002e-07 0 7.02000000000002e-07 0 7.02100000000002e-07 1 7.06500000000002e-07 1 7.06550000000002e-07 0 7.08000000000002e-07 0 7.08100000000002e-07 1 7.12500000000002e-07 1 7.12550000000002e-07 0 7.14000000000002e-07 0 7.14100000000002e-07 1 7.18500000000002e-07 1 7.18550000000002e-07 0 7.20000000000002e-07 0 7.20100000000002e-07 1 7.24500000000002e-07 1 7.24550000000002e-07 0 7.26000000000002e-07 0 7.26100000000002e-07 1 7.30500000000002e-07 1 7.30550000000002e-07 0 7.32000000000002e-07 0 7.32100000000002e-07 1 7.36500000000002e-07 1 7.36550000000002e-07 0 7.38000000000002e-07 0 7.38100000000002e-07 1 7.42500000000002e-07 1 7.42550000000002e-07 0 7.44000000000002e-07 0 7.44100000000002e-07 1 7.48500000000002e-07 1 7.48550000000002e-07 0 7.50000000000002e-07 0 7.50100000000002e-07 1 7.54500000000002e-07 1 7.54550000000002e-07 0 7.56000000000002e-07 0 7.56100000000002e-07 1 7.60500000000002e-07 1 7.60550000000002e-07 0 7.62000000000002e-07 0 7.62100000000002e-07 1 7.66500000000002e-07 1 7.66550000000002e-07 0 7.68000000000002e-07 0 7.68100000000002e-07 1 7.72500000000002e-07 1 7.72550000000002e-07 0 7.74000000000002e-07 0 7.74100000000002e-07 1 7.78500000000002e-07 1 7.78550000000002e-07 0 7.80000000000002e-07 0 7.80100000000002e-07 1 7.84500000000003e-07 1 7.84550000000003e-07 0 7.86000000000003e-07 0 7.86100000000003e-07 1 7.90500000000003e-07 1 7.90550000000003e-07 0 7.92000000000003e-07 0 7.92100000000003e-07 1 7.96500000000003e-07 1 7.96550000000003e-07 0 7.98000000000003e-07 0 7.98100000000003e-07 1 8.02500000000003e-07 1 8.02550000000003e-07 0 8.04000000000003e-07 0 8.04100000000003e-07 1 8.08500000000003e-07 1 8.08550000000003e-07 0 8.10000000000003e-07 0 8.10100000000003e-07 1 8.14500000000003e-07 1 8.14550000000003e-07 0 8.16000000000003e-07 0 8.16100000000003e-07 1 8.20500000000003e-07 1 8.20550000000003e-07 0 8.22000000000003e-07 0 8.22100000000003e-07 1 8.26500000000003e-07 1 8.26550000000003e-07 0 8.28000000000003e-07 0 8.28100000000003e-07 1 8.32500000000003e-07 1 8.32550000000003e-07 0 8.34000000000003e-07 0 8.34100000000003e-07 1 8.38500000000003e-07 1 8.38550000000003e-07 0 8.40000000000003e-07 0 8.40100000000003e-07 1 8.44500000000003e-07 1 8.44550000000003e-07 0 8.46000000000003e-07 0 8.46100000000003e-07 1 8.50500000000003e-07 1 8.50550000000003e-07 0 8.52000000000003e-07 0 8.52100000000003e-07 1 8.56500000000003e-07 1 8.56550000000003e-07 0 8.58000000000003e-07 0 8.58100000000003e-07 1 8.62500000000003e-07 1 8.62550000000003e-07 0 8.64000000000003e-07 0 8.64100000000003e-07 1 8.68500000000003e-07 1 8.68550000000003e-07 0 8.70000000000003e-07 0 8.70100000000003e-07 1 8.74500000000003e-07 1 8.74550000000003e-07 0 8.76000000000003e-07 0 8.76100000000003e-07 1 8.80500000000003e-07 1 8.80550000000003e-07 0 8.82000000000003e-07 0 8.82100000000003e-07 1 8.86500000000003e-07 1 8.86550000000003e-07 0 8.88000000000003e-07 0 8.88100000000003e-07 1 8.92500000000003e-07 1 8.92550000000003e-07 0 8.94000000000003e-07 0 8.94100000000003e-07 1 8.98500000000003e-07 1 8.98550000000003e-07 0 9.00000000000003e-07 0 9.00100000000003e-07 1 9.04500000000003e-07 1 9.04550000000003e-07 0 9.06000000000003e-07 0 9.06100000000003e-07 1 9.10500000000003e-07 1 9.10550000000003e-07 0 9.12000000000003e-07 0 9.12100000000003e-07 1 9.16500000000003e-07 1 9.16550000000003e-07 0 9.18000000000003e-07 0 9.18100000000003e-07 1 9.22500000000003e-07 1 9.22550000000003e-07 0 9.24000000000003e-07 0 9.24100000000003e-07 1 9.28500000000003e-07 1 9.28550000000003e-07 0 9.30000000000003e-07 0 9.30100000000003e-07 1 9.34500000000003e-07 1 9.34550000000003e-07 0 9.36000000000003e-07 0 9.36100000000003e-07 1 9.40500000000003e-07 1 9.40550000000003e-07 0 9.42000000000003e-07 0 9.42100000000003e-07 1 9.46500000000003e-07 1 9.46550000000003e-07 0 9.48000000000003e-07 0 9.48100000000003e-07 1 9.52500000000003e-07 1 9.52550000000003e-07 0 9.54000000000003e-07 0 9.54100000000003e-07 1 9.58500000000003e-07 1 9.58550000000003e-07 0 9.60000000000003e-07 0 9.60100000000003e-07 1 9.64500000000003e-07 1 9.64550000000003e-07 0 9.66000000000003e-07 0 9.66100000000003e-07 1 9.70500000000003e-07 1 9.70550000000003e-07 0 9.72000000000003e-07 0 9.72100000000003e-07 1 9.76500000000003e-07 1 9.76550000000003e-07 0 9.78000000000003e-07 0 9.78100000000003e-07 1 9.82500000000003e-07 1 9.82550000000003e-07 0 9.84000000000003e-07 0 9.84100000000003e-07 1 9.88500000000003e-07 1 9.88550000000003e-07 0 9.90000000000003e-07 0 9.90100000000003e-07 1 9.94500000000003e-07 1 9.94550000000003e-07 0 9.96000000000003e-07 0 9.96100000000003e-07 1 1.0005e-06 1 1.00055e-06 0 1.002e-06 0 1.0021e-06 1 1.0065e-06 1 1.00655e-06 0 1.008e-06 0 1.0081e-06 1 1.0125e-06 1 1.01255e-06 0 1.014e-06 0 1.0141e-06 1 1.0185e-06 1 1.01855e-06 0 1.02e-06 0 1.0201e-06 1 1.0245e-06 1 1.02455e-06 0 1.026e-06 0 1.0261e-06 1 1.0305e-06 1 1.03055e-06 0 1.032e-06 0 1.0321e-06 1 1.0365e-06 1 1.03655e-06 0 1.038e-06 0 1.0381e-06 1 1.0425e-06 1 1.04255e-06 0 1.044e-06 0 1.0441e-06 1 1.0485e-06 1 1.04855e-06 0 1.05e-06 0 1.0501e-06 1 1.0545e-06 1 1.05455e-06 0 1.056e-06 0 1.0561e-06 1 1.0605e-06 1 1.06055e-06 0 1.062e-06 0 1.0621e-06 1 1.0665e-06 1 1.06655e-06 0 1.068e-06 0 1.0681e-06 1 1.0725e-06 1 1.07255e-06 0 1.074e-06 0 1.0741e-06 1 1.0785e-06 1 1.07855e-06 0 1.08e-06 0 1.0801e-06 1 1.0845e-06 1 1.08455e-06 0 1.086e-06 0 1.0861e-06 1 1.0905e-06 1 1.09055e-06 0 1.092e-06 0 1.0921e-06 1 1.0965e-06 1 1.09655e-06 0 1.098e-06 0 1.0981e-06 1 1.1025e-06 1 1.10255e-06 0 1.104e-06 0 1.1041e-06 1 1.1085e-06 1 1.10855e-06 0 1.11e-06 0 1.1101e-06 1 1.1145e-06 1 1.11455e-06 0 1.116e-06 0 1.1161e-06 1 1.1205e-06 1 1.12055e-06 0 1.122e-06 0 1.1221e-06 1 1.1265e-06 1 1.12655e-06 0 1.128e-06 0 1.1281e-06 1 1.1325e-06 1 1.13255e-06 0 1.134e-06 0 1.1341e-06 1 1.1385e-06 1 1.13855e-06 0 1.14e-06 0 1.1401e-06 1 1.1445e-06 1 1.14455e-06 0 1.146e-06 0 1.1461e-06 1 1.1505e-06 1 1.15055e-06 0 1.152e-06 0 1.1521e-06 1 1.1565e-06 1 1.15655e-06 0 1.158e-06 0 1.1581e-06 1 1.1625e-06 1 1.16255e-06 0 1.164e-06 0 1.1641e-06 1 1.1685e-06 1 1.16855e-06 0 1.17e-06 0 1.1701e-06 1 1.1745e-06 1 1.17455e-06 0 1.176e-06 0 1.1761e-06 1 1.1805e-06 1 1.18055e-06 0 1.182e-06 0 1.1821e-06 1 1.1865e-06 1 1.18655e-06 0 1.188e-06 0 1.1881e-06 1 1.1925e-06 1 1.19255e-06 0 1.194e-06 0 1.1941e-06 1 1.1985e-06 1 1.19855e-06 0 1.2e-06 0 1.2001e-06 1 1.2045e-06 1 1.20455e-06 0 1.206e-06 0 1.2061e-06 1 1.2105e-06 1 1.21055e-06 0 1.212e-06 0 1.2121e-06 1 1.2165e-06 1 1.21655e-06 0 1.218e-06 0 1.2181e-06 1 1.2225e-06 1 1.22255e-06 0 1.224e-06 0 1.2241e-06 1 1.2285e-06 1 1.22855e-06 0 1.23e-06 0 1.2301e-06 1 1.2345e-06 1 1.23455e-06 0 1.236e-06 0 1.2361e-06 1 1.2405e-06 1 1.24055e-06 0 1.242e-06 0 1.2421e-06 1 1.2465e-06 1 1.24655e-06 0 1.248e-06 0 1.2481e-06 1 1.2525e-06 1 1.25255e-06 0 1.254e-06 0 1.2541e-06 1 1.2585e-06 1 1.25855e-06 0 1.26e-06 0 1.2601e-06 1 1.2645e-06 1 1.26455e-06 0 1.266e-06 0 1.2661e-06 1 1.2705e-06 1 1.27055e-06 0 1.272e-06 0 1.2721e-06 1 1.2765e-06 1 1.27655e-06 0 1.278e-06 0 1.2781e-06 1 1.2825e-06 1 1.28255e-06 0 1.284e-06 0 1.2841e-06 1 1.2885e-06 1 1.28855e-06 0 1.29e-06 0 1.2901e-06 1 1.2945e-06 1 1.29455e-06 0 1.296e-06 0 1.2961e-06 1 1.3005e-06 1 1.30055e-06 0 1.302e-06 0 1.3021e-06 1 1.3065e-06 1 1.30655e-06 0 1.308e-06 0 1.3081e-06 1 1.3125e-06 1 1.31255e-06 0 1.314e-06 0 1.3141e-06 1 1.3185e-06 1 1.31855e-06 0 1.32e-06 0 1.3201e-06 1 1.3245e-06 1 1.32455e-06 0 1.326e-06 0 1.3261e-06 1 1.3305e-06 1 1.33055e-06 0 1.332e-06 0 1.3321e-06 1 1.3365e-06 1 1.33655e-06 0 1.33800000000001e-06 0 1.33810000000001e-06 1 1.3425e-06 1 1.34255e-06 0 1.34400000000001e-06 0 1.34410000000001e-06 1 1.3485e-06 1 1.34855e-06 0 1.35000000000001e-06 0 1.35010000000001e-06 1 1.3545e-06 1 1.35455e-06 0 1.35600000000001e-06 0 1.35610000000001e-06 1 1.36050000000001e-06 1 1.36055e-06 0 1.36200000000001e-06 0 1.36210000000001e-06 1 1.36650000000001e-06 1 1.36655e-06 0 1.36800000000001e-06 0 1.36810000000001e-06 1 1.37250000000001e-06 1 1.37255e-06 0 1.37400000000001e-06 0 1.37410000000001e-06 1 1.37850000000001e-06 1 1.37855e-06 0 1.38000000000001e-06 0 1.38010000000001e-06 1 1.38450000000001e-06 1 1.38455000000001e-06 0 1.38600000000001e-06 0 1.38610000000001e-06 1 1.39050000000001e-06 1 1.39055000000001e-06 0 1.39200000000001e-06 0 1.39210000000001e-06 1 1.39650000000001e-06 1 1.39655000000001e-06 0 1.39800000000001e-06 0 1.39810000000001e-06 1 1.40250000000001e-06 1 1.40255000000001e-06 0 1.40400000000001e-06 0 1.40410000000001e-06 1 1.40850000000001e-06 1 1.40855000000001e-06 0 1.41000000000001e-06 0 1.41010000000001e-06 1 1.41450000000001e-06 1 1.41455000000001e-06 0 1.41600000000001e-06 0 1.41610000000001e-06 1 1.42050000000001e-06 1 1.42055000000001e-06 0 1.42200000000001e-06 0 1.42210000000001e-06 1 1.42650000000001e-06 1 1.42655000000001e-06 0 1.42800000000001e-06 0 1.42810000000001e-06 1 1.43250000000001e-06 1 1.43255000000001e-06 0 1.43400000000001e-06 0 1.43410000000001e-06 1 1.43850000000001e-06 1 1.43855000000001e-06 0 1.44000000000001e-06 0 1.44010000000001e-06 1 1.44450000000001e-06 1 1.44455000000001e-06 0 1.44600000000001e-06 0 1.44610000000001e-06 1 1.45050000000001e-06 1 1.45055000000001e-06 0 1.45200000000001e-06 0 1.45210000000001e-06 1 1.45650000000001e-06 1 1.45655000000001e-06 0 1.45800000000001e-06 0 1.45810000000001e-06 1 1.46250000000001e-06 1 1.46255000000001e-06 0 1.46400000000001e-06 0 1.46410000000001e-06 1 1.46850000000001e-06 1 1.46855000000001e-06 0 1.47000000000001e-06 0 1.47010000000001e-06 1 1.47450000000001e-06 1 1.47455000000001e-06 0 1.47600000000001e-06 0 1.47610000000001e-06 1 1.48050000000001e-06 1 1.48055000000001e-06 0 1.48200000000001e-06 0 1.48210000000001e-06 1 1.48650000000001e-06 1 1.48655000000001e-06 0 1.48800000000001e-06 0 1.48810000000001e-06 1 1.49250000000001e-06 1 1.49255000000001e-06 0 1.49400000000001e-06 0 1.49410000000001e-06 1 1.49850000000001e-06 1 1.49855000000001e-06 0 1.50000000000001e-06 0 1.50010000000001e-06 1 1.50450000000001e-06 1 1.50455000000001e-06 0 1.50600000000001e-06 0 1.50610000000001e-06 1 1.51050000000001e-06 1 1.51055000000001e-06 0 1.51200000000001e-06 0 1.51210000000001e-06 1 1.51650000000001e-06 1 1.51655000000001e-06 0 1.51800000000001e-06 0 1.51810000000001e-06 1 1.52250000000001e-06 1 1.52255000000001e-06 0 1.52400000000001e-06 0 1.52410000000001e-06 1 1.52850000000001e-06 1 1.52855000000001e-06 0 1.53000000000001e-06 0 1.53010000000001e-06 1 1.53450000000001e-06 1 1.53455000000001e-06 0 1.53600000000001e-06 0 1.53610000000001e-06 1 1.54050000000001e-06 1 1.54055000000001e-06 0 1.54200000000001e-06 0 1.54210000000001e-06 1 1.54650000000001e-06 1 1.54655000000001e-06 0 1.54800000000001e-06 0 1.54810000000001e-06 1 1.55250000000001e-06 1 1.55255000000001e-06 0 1.55400000000001e-06 0 1.55410000000001e-06 1 1.55850000000001e-06 1 1.55855000000001e-06 0 1.56000000000001e-06 0 1.56010000000001e-06 1 1.56450000000001e-06 1 1.56455000000001e-06 0 1.56600000000001e-06 0 1.56610000000001e-06 1 1.57050000000001e-06 1 1.57055000000001e-06 0 1.57200000000001e-06 0 1.57210000000001e-06 1 1.57650000000001e-06 1 1.57655000000001e-06 0 1.57800000000001e-06 0 1.57810000000001e-06 1 1.58250000000001e-06 1 1.58255000000001e-06 0 1.58400000000001e-06 0 1.58410000000001e-06 1 1.58850000000001e-06 1 1.58855000000001e-06 0 1.59000000000001e-06 0 1.59010000000001e-06 1 1.59450000000001e-06 1 1.59455000000001e-06 0 1.59600000000001e-06 0 1.59610000000001e-06 1 1.60050000000001e-06 1 1.60055000000001e-06 0 1.60200000000001e-06 0 1.60210000000001e-06 1 1.60650000000001e-06 1 1.60655000000001e-06 0 1.60800000000001e-06 0 1.60810000000001e-06 1 1.61250000000001e-06 1 1.61255000000001e-06 0 1.61400000000001e-06 0 1.61410000000001e-06 1 1.61850000000001e-06 1 1.61855000000001e-06 0 1.62000000000001e-06 0 1.62010000000001e-06 1 1.62450000000001e-06 1 1.62455000000001e-06 0 1.62600000000001e-06 0 1.62610000000001e-06 1 1.63050000000001e-06 1 1.63055000000001e-06 0 1.63200000000001e-06 0 1.63210000000001e-06 1 1.63650000000001e-06 1 1.63655000000001e-06 0 1.63800000000001e-06 0 1.63810000000001e-06 1 1.64250000000001e-06 1 1.64255000000001e-06 0 1.64400000000001e-06 0 1.64410000000001e-06 1 1.64850000000001e-06 1 1.64855000000001e-06 0 1.65000000000001e-06 0 1.65010000000001e-06 1 1.65450000000001e-06 1 1.65455000000001e-06 0 1.65600000000001e-06 0 1.65610000000001e-06 1 1.66050000000001e-06 1 1.66055000000001e-06 0 1.66200000000001e-06 0 1.66210000000001e-06 1 1.66650000000001e-06 1 1.66655000000001e-06 0 1.66800000000001e-06 0 1.66810000000001e-06 1 1.67250000000001e-06 1 1.67255000000001e-06 0 1.67400000000001e-06 0 1.67410000000001e-06 1 1.67850000000001e-06 1 1.67855000000001e-06 0 1.68000000000001e-06 0 1.68010000000001e-06 1 1.68450000000001e-06 1 1.68455000000001e-06 0 1.68600000000001e-06 0 1.68610000000001e-06 1 1.69050000000001e-06 1 1.69055000000001e-06 0 1.69200000000001e-06 0 1.69210000000001e-06 1 1.69650000000001e-06 1 1.69655000000001e-06 0 1.69800000000001e-06 0 1.69810000000001e-06 1 1.70250000000001e-06 1 1.70255000000001e-06 0 1.70400000000001e-06 0 1.70410000000001e-06 1 1.70850000000001e-06 1 1.70855000000001e-06 0 1.71000000000001e-06 0 1.71010000000001e-06 1 1.71450000000001e-06 1 1.71455000000001e-06 0 1.71600000000001e-06 0 1.71610000000001e-06 1 1.72050000000001e-06 1 1.72055000000001e-06 0 1.72200000000001e-06 0 1.72210000000001e-06 1 1.72650000000001e-06 1 1.72655000000001e-06 0 1.72800000000001e-06 0 1.72810000000001e-06 1 1.73250000000001e-06 1 1.73255000000001e-06 0 1.73400000000001e-06 0 1.73410000000001e-06 1 1.73850000000001e-06 1 1.73855000000001e-06 0 1.74000000000001e-06 0 1.74010000000001e-06 1 1.74450000000001e-06 1 1.74455000000001e-06 0 1.74600000000001e-06 0 1.74610000000001e-06 1 1.75050000000001e-06 1 1.75055000000001e-06 0 1.75200000000001e-06 0 1.75210000000001e-06 1 1.75650000000001e-06 1 1.75655000000001e-06 0 1.75800000000001e-06 0 1.75810000000001e-06 1 1.76250000000001e-06 1 1.76255000000001e-06 0 1.76400000000001e-06 0 1.76410000000001e-06 1 1.76850000000001e-06 1 1.76855000000001e-06 0 1.77000000000001e-06 0 1.77010000000001e-06 1 1.77450000000001e-06 1 1.77455000000001e-06 0 1.77600000000001e-06 0 1.77610000000001e-06 1 1.78050000000001e-06 1 1.78055000000001e-06 0 1.78200000000001e-06 0 1.78210000000001e-06 1 1.78650000000001e-06 1 1.78655000000001e-06 0 1.78800000000001e-06 0 1.78810000000001e-06 1 1.79250000000001e-06 1 1.79255000000001e-06 0 1.79400000000001e-06 0 1.79410000000001e-06 1 1.79850000000001e-06 1 1.79855000000001e-06 0 1.80000000000001e-06 0 1.80010000000001e-06 1 1.80450000000001e-06 1 1.80455000000001e-06 0 1.80600000000001e-06 0 1.80610000000001e-06 1 1.81050000000001e-06 1 1.81055000000001e-06 0 1.81200000000001e-06 0 1.81210000000001e-06 1 1.81650000000001e-06 1 1.81655000000001e-06 0 1.81800000000001e-06 0 1.81810000000001e-06 1 1.82250000000001e-06 1 1.82255000000001e-06 0 1.82400000000001e-06 0 1.82410000000001e-06 1 1.82850000000001e-06 1 1.82855000000001e-06 0 1.83000000000001e-06 0 1.83010000000001e-06 1 1.83450000000001e-06 1 1.83455000000001e-06 0 1.83600000000001e-06 0 1.83610000000001e-06 1 1.84050000000001e-06 1 1.84055000000001e-06 0 1.84200000000001e-06 0 1.84210000000001e-06 1 1.84650000000001e-06 1 1.84655000000001e-06 0 1.84800000000001e-06 0 1.84810000000001e-06 1 1.85250000000001e-06 1 1.85255000000001e-06 0 1.85400000000001e-06 0 1.85410000000001e-06 1 1.85850000000001e-06 1 1.85855000000001e-06 0 1.86000000000001e-06 0 1.86010000000001e-06 1 1.86450000000001e-06 1 1.86455000000001e-06 0 1.86600000000001e-06 0 1.86610000000001e-06 1 1.87050000000001e-06 1 1.87055000000001e-06 0 1.87200000000001e-06 0 1.87210000000001e-06 1 1.87650000000001e-06 1 1.87655000000001e-06 0 1.87800000000001e-06 0 1.87810000000001e-06 1 1.88250000000001e-06 1 1.88255000000001e-06 0 1.88400000000001e-06 0 1.88410000000001e-06 1 1.88850000000001e-06 1 1.88855000000001e-06 0 1.89000000000001e-06 0 1.89010000000001e-06 1 1.89450000000001e-06 1 1.89455000000001e-06 0 1.89600000000001e-06 0 1.89610000000001e-06 1 1.90050000000001e-06 1 1.90055000000001e-06 0 1.90200000000001e-06 0 1.90210000000001e-06 1 1.90650000000001e-06 1 1.90655000000001e-06 0 1.90800000000001e-06 0 1.90810000000001e-06 1 1.91250000000001e-06 1 1.91255000000001e-06 0 1.91400000000001e-06 0 1.91410000000001e-06 1 1.91850000000001e-06 1 1.91855000000001e-06 0 1.92000000000001e-06 0 1.92010000000001e-06 1 1.92450000000001e-06 1 1.92455000000001e-06 0 1.92600000000001e-06 0 1.92610000000001e-06 1 1.93050000000001e-06 1 1.93055000000001e-06 0 1.93200000000001e-06 0 1.93210000000001e-06 1 1.93650000000001e-06 1 1.93655000000001e-06 0 1.93800000000001e-06 0 1.93810000000001e-06 1 1.94250000000001e-06 1 1.94255000000001e-06 0 1.94400000000001e-06 0 1.94410000000001e-06 1 1.94850000000001e-06 1 1.94855000000001e-06 0 1.95000000000001e-06 0 1.95010000000001e-06 1 1.95450000000001e-06 1 1.95455000000001e-06 0 1.95600000000001e-06 0 1.95610000000001e-06 1 1.96050000000001e-06 1 1.96055000000001e-06 0 1.96200000000001e-06 0 1.96210000000001e-06 1 1.96650000000001e-06 1 1.96655000000001e-06 0 1.96800000000001e-06 0 1.96810000000001e-06 1 1.97250000000001e-06 1 1.97255000000001e-06 0 1.97400000000001e-06 0 1.97410000000001e-06 1 1.97850000000001e-06 1 1.97855000000001e-06 0 1.98000000000001e-06 0 1.98010000000001e-06 1 1.98450000000001e-06 1 1.98455000000001e-06 0 1.98600000000001e-06 0 1.98610000000001e-06 1 1.99050000000001e-06 1 1.99055000000001e-06 0 1.99200000000001e-06 0 1.99210000000001e-06 1 1.99650000000001e-06 1 1.99655000000001e-06 0 1.99800000000001e-06 0 1.99810000000001e-06 1 2.00250000000001e-06 1 2.00255000000001e-06 0 2.00400000000001e-06 0 2.00410000000001e-06 1 2.00850000000001e-06 1 2.00855000000001e-06 0 2.01000000000001e-06 0 2.01010000000001e-06 1 2.01450000000001e-06 1 2.01455000000001e-06 0 2.01600000000001e-06 0 2.01610000000001e-06 1 2.02050000000001e-06 1 2.02055000000001e-06 0 2.02200000000001e-06 0 2.02210000000001e-06 1 2.02650000000001e-06 1 2.02655000000001e-06 0 2.02800000000001e-06 0 2.02810000000001e-06 1 2.03250000000001e-06 1 2.03255000000001e-06 0 2.03400000000001e-06 0 2.03410000000001e-06 1 2.03850000000001e-06 1 2.03855000000001e-06 0 2.04000000000001e-06 0 2.04010000000001e-06 1 2.04450000000001e-06 1 2.04455000000001e-06 0 2.04600000000001e-06 0 2.04610000000001e-06 1 2.05050000000001e-06 1 2.05055000000001e-06 0 2.05200000000001e-06 0 2.05210000000001e-06 1 2.05650000000001e-06 1 2.05655000000001e-06 0 2.05800000000001e-06 0 2.05810000000001e-06 1 2.06250000000001e-06 1 2.06255000000001e-06 0 2.06400000000001e-06 0 2.06410000000001e-06 1 2.06850000000001e-06 1 2.06855000000001e-06 0 2.07000000000001e-06 0 2.07010000000001e-06 1 2.07450000000001e-06 1 2.07455000000001e-06 0 2.07600000000001e-06 0 2.07610000000001e-06 1 2.08050000000001e-06 1 2.08055000000001e-06 0 2.08200000000001e-06 0 2.08210000000001e-06 1 2.08650000000001e-06 1 2.08655000000001e-06 0 2.08800000000001e-06 0 2.08810000000001e-06 1 2.09250000000001e-06 1 2.09255000000001e-06 0 2.09400000000001e-06 0 2.09410000000001e-06 1 2.09850000000001e-06 1 2.09855000000001e-06 0 2.10000000000001e-06 0 2.10010000000001e-06 1 2.10450000000001e-06 1 2.10455000000001e-06 0 2.10600000000001e-06 0 2.10610000000001e-06 1 2.11050000000001e-06 1 2.11055000000001e-06 0 2.11200000000001e-06 0 2.11210000000001e-06 1 2.11650000000001e-06 1 2.11655000000001e-06 0 2.11800000000001e-06 0 2.11810000000001e-06 1 2.12250000000001e-06 1 2.12255000000001e-06 0 2.12400000000001e-06 0 2.12410000000001e-06 1 2.12850000000001e-06 1 2.12855000000001e-06 0 2.13000000000001e-06 0 2.13010000000001e-06 1 2.13450000000001e-06 1 2.13455000000001e-06 0 2.13600000000001e-06 0 2.13610000000001e-06 1 2.14050000000001e-06 1 2.14055000000001e-06 0 2.14200000000001e-06 0 2.14210000000001e-06 1 2.14650000000001e-06 1 2.14655000000001e-06 0 2.14800000000001e-06 0 2.14810000000001e-06 1 2.15250000000001e-06 1 2.15255000000001e-06 0 2.15400000000001e-06 0 2.15410000000001e-06 1 2.15850000000001e-06 1 2.15855000000001e-06 0 2.16000000000001e-06 0 2.16010000000001e-06 1 2.16450000000001e-06 1 2.16455000000001e-06 0 2.16600000000001e-06 0 2.16610000000001e-06 1 2.17050000000001e-06 1 2.17055000000001e-06 0 2.17200000000001e-06 0 2.17210000000001e-06 1 2.17650000000001e-06 1 2.17655000000001e-06 0 2.17800000000001e-06 0 2.17810000000001e-06 1 2.18250000000001e-06 1 2.18255000000001e-06 0 2.18400000000001e-06 0 2.18410000000001e-06 1 2.18850000000001e-06 1 2.18855000000001e-06 0 2.19000000000001e-06 0 2.19010000000001e-06 1 2.19450000000001e-06 1 2.19455000000001e-06 0 2.19600000000001e-06 0 2.19610000000001e-06 1 2.20050000000001e-06 1 2.20055000000001e-06 0 2.20200000000001e-06 0 2.20210000000001e-06 1 2.20650000000001e-06 1 2.20655000000001e-06 0 2.20800000000001e-06 0 2.20810000000001e-06 1 2.21250000000001e-06 1 2.21255000000001e-06 0 2.21400000000001e-06 0 2.21410000000001e-06 1 2.21850000000001e-06 1 2.21855000000001e-06 0 2.22000000000001e-06 0 2.22010000000001e-06 1 2.22450000000001e-06 1 2.22455000000001e-06 0 2.22600000000001e-06 0 2.22610000000001e-06 1 2.23050000000001e-06 1 2.23055000000001e-06 0 2.23200000000001e-06 0 2.23210000000001e-06 1 2.23650000000001e-06 1 2.23655000000001e-06 0 2.23800000000001e-06 0 2.23810000000001e-06 1 2.24250000000001e-06 1 2.24255000000001e-06 0 2.24400000000001e-06 0 2.24410000000001e-06 1 2.24850000000001e-06 1 2.24855000000001e-06 0 2.25000000000001e-06 0 2.25010000000001e-06 1 2.25450000000001e-06 1 2.25455000000001e-06 0 2.25600000000001e-06 0 2.25610000000001e-06 1 2.26050000000001e-06 1 2.26055000000001e-06 0 2.26200000000001e-06 0 2.26210000000001e-06 1 2.26650000000001e-06 1 2.26655000000001e-06 0 2.26800000000001e-06 0 2.26810000000001e-06 1 2.27250000000001e-06 1 2.27255000000001e-06 0 2.27400000000001e-06 0 2.27410000000001e-06 1 2.27850000000001e-06 1 2.27855000000001e-06 0 2.28000000000001e-06 0 2.28010000000001e-06 1 2.28450000000001e-06 1 2.28455000000001e-06 0 2.28600000000001e-06 0 2.28610000000001e-06 1 2.29050000000001e-06 1 2.29055000000001e-06 0 2.29200000000001e-06 0 2.29210000000001e-06 1 2.29650000000001e-06 1 2.29655000000001e-06 0 2.29800000000001e-06 0 2.29810000000001e-06 1 2.30250000000001e-06 1 2.30255000000001e-06 0 2.30400000000001e-06 0 2.30410000000001e-06 1 2.30850000000001e-06 1 2.30855000000001e-06 0 2.31000000000001e-06 0 2.31010000000001e-06 1 2.31450000000001e-06 1 2.31455000000001e-06 0 2.31600000000001e-06 0 2.31610000000001e-06 1 2.32050000000001e-06 1 2.32055000000001e-06 0 2.32200000000001e-06 0 2.32210000000001e-06 1 2.32650000000001e-06 1 2.32655000000001e-06 0 2.32800000000001e-06 0 2.32810000000001e-06 1 2.33250000000001e-06 1 2.33255000000001e-06 0 2.33400000000001e-06 0 2.33410000000001e-06 1 2.33850000000001e-06 1 2.33855000000001e-06 0 2.34000000000001e-06 0 2.34010000000001e-06 1 2.34450000000001e-06 1 2.34455000000001e-06 0 2.34600000000001e-06 0 2.34610000000001e-06 1 2.35050000000001e-06 1 2.35055000000001e-06 0 2.35200000000001e-06 0 2.35210000000001e-06 1 2.35650000000001e-06 1 2.35655000000001e-06 0 2.35800000000001e-06 0 2.35810000000001e-06 1 2.36250000000001e-06 1 2.36255000000001e-06 0 2.36400000000001e-06 0 2.36410000000001e-06 1 2.36850000000001e-06 1 2.36855000000001e-06 0 2.37000000000001e-06 0 2.37010000000001e-06 1 2.37450000000001e-06 1 2.37455000000001e-06 0 2.37600000000001e-06 0 2.37610000000001e-06 1 2.38050000000001e-06 1 2.38055000000001e-06 0 2.38200000000001e-06 0 2.38210000000001e-06 1 2.38650000000001e-06 1 2.38655000000001e-06 0 2.38800000000001e-06 0 2.38810000000001e-06 1 2.39250000000001e-06 1 2.39255000000001e-06 0 2.39400000000001e-06 0 2.39410000000001e-06 1 2.39850000000001e-06 1 2.39855000000001e-06 0 2.40000000000001e-06 0 2.40010000000001e-06 1 2.40450000000001e-06 1 2.40455000000001e-06 0 2.40600000000001e-06 0 2.40610000000001e-06 1 2.41050000000001e-06 1 2.41055000000001e-06 0 2.41200000000001e-06 0 2.41210000000001e-06 1 2.41650000000001e-06 1 2.41655000000001e-06 0 2.41800000000001e-06 0 2.41810000000001e-06 1 2.42250000000001e-06 1 2.42255000000001e-06 0 2.42400000000001e-06 0 2.42410000000001e-06 1 2.42850000000001e-06 1 2.42855000000001e-06 0 2.43000000000001e-06 0 2.43010000000001e-06 1 2.43450000000001e-06 1 2.43455000000001e-06 0 2.43600000000001e-06 0 2.43610000000001e-06 1 2.44050000000001e-06 1 2.44055000000001e-06 0 2.44200000000001e-06 0 2.44210000000001e-06 1 2.44650000000001e-06 1 2.44655000000001e-06 0 2.44800000000001e-06 0 2.44810000000001e-06 1 2.45250000000001e-06 1 2.45255000000001e-06 0 2.45400000000001e-06 0 2.45410000000001e-06 1 2.45850000000001e-06 1 2.45855000000001e-06 0 2.46000000000001e-06 0 2.46010000000001e-06 1 2.46450000000001e-06 1 2.46455000000001e-06 0 2.46600000000001e-06 0 2.46610000000001e-06 1 2.47050000000001e-06 1 2.47055000000001e-06 0 2.47200000000001e-06 0 2.47210000000001e-06 1 2.47650000000001e-06 1 2.47655000000001e-06 0 2.47800000000001e-06 0 2.47810000000001e-06 1 2.48250000000001e-06 1 2.48255000000001e-06 0 2.48400000000001e-06 0 2.48410000000001e-06 1 2.48850000000001e-06 1 2.48855000000001e-06 0 2.49000000000001e-06 0 2.49010000000001e-06 1 2.49450000000001e-06 1 2.49455000000001e-06 0 2.49600000000001e-06 0 2.49610000000001e-06 1 2.50050000000001e-06 1 2.50055000000001e-06 0 2.50200000000001e-06 0 2.50210000000001e-06 1 2.50650000000001e-06 1 2.50655000000001e-06 0 2.50800000000001e-06 0 2.50810000000001e-06 1 2.51250000000001e-06 1 2.51255000000001e-06 0 2.51400000000001e-06 0 2.51410000000001e-06 1 2.51850000000001e-06 1 2.51855000000001e-06 0 2.52000000000001e-06 0 2.52010000000001e-06 1 2.52450000000001e-06 1 2.52455000000001e-06 0 2.52600000000001e-06 0 2.52610000000001e-06 1 2.53050000000001e-06 1 2.53055000000001e-06 0 2.53200000000001e-06 0 2.53210000000001e-06 1 2.53650000000001e-06 1 2.53655000000001e-06 0 2.53800000000001e-06 0 2.53810000000001e-06 1 2.54250000000001e-06 1 2.54255000000001e-06 0 2.54400000000001e-06 0 2.54410000000001e-06 1 2.54850000000001e-06 1 2.54855000000001e-06 0 2.55000000000001e-06 0 2.55010000000001e-06 1 2.55450000000001e-06 1 2.55455000000001e-06 0 2.55600000000001e-06 0 2.55610000000001e-06 1 2.56050000000001e-06 1 2.56055000000001e-06 0 2.56200000000001e-06 0 2.56210000000001e-06 1 2.56650000000001e-06 1 2.56655000000001e-06 0 2.56800000000001e-06 0 2.56810000000001e-06 1 2.57250000000001e-06 1 2.57255000000001e-06 0 2.57400000000001e-06 0 2.57410000000001e-06 1 2.57850000000001e-06 1 2.57855000000001e-06 0 2.58000000000001e-06 0 2.58010000000001e-06 1 2.58450000000001e-06 1 2.58455000000001e-06 0 2.58600000000001e-06 0 2.58610000000001e-06 1 2.59050000000001e-06 1 2.59055000000001e-06 0 2.59200000000001e-06 0 2.59210000000001e-06 1 2.59650000000001e-06 1 2.59655000000001e-06 0 2.59800000000001e-06 0 2.59810000000001e-06 1 2.60250000000001e-06 1 2.60255000000001e-06 0 2.60400000000001e-06 0 2.60410000000001e-06 1 2.60850000000001e-06 1 2.60855000000001e-06 0 2.61000000000001e-06 0 2.61010000000001e-06 1 2.61450000000001e-06 1 2.61455000000001e-06 0 2.61600000000001e-06 0 2.61610000000001e-06 1 2.62050000000001e-06 1 2.62055000000001e-06 0 2.62200000000001e-06 0 2.62210000000001e-06 1 2.62650000000001e-06 1 2.62655000000001e-06 0 2.62800000000001e-06 0 2.62810000000001e-06 1 2.63250000000001e-06 1 2.63255000000001e-06 0 2.63400000000001e-06 0 2.63410000000001e-06 1 2.63850000000001e-06 1 2.63855000000001e-06 0 2.64000000000001e-06 0 2.64010000000001e-06 1 2.64450000000001e-06 1 2.64455000000001e-06 0 2.64600000000001e-06 0 2.64610000000001e-06 1 2.65050000000001e-06 1 2.65055000000001e-06 0 2.65200000000001e-06 0 2.65210000000001e-06 1 2.65650000000001e-06 1 2.65655000000001e-06 0 2.65800000000001e-06 0 2.65810000000001e-06 1 2.66250000000001e-06 1 2.66255000000001e-06 0 2.66400000000001e-06 0 2.66410000000001e-06 1 2.66850000000001e-06 1 2.66855000000001e-06 0 2.67000000000001e-06 0 2.67010000000001e-06 1 2.67450000000001e-06 1 2.67455000000001e-06 0 2.67600000000001e-06 0 2.67610000000001e-06 1 2.68050000000001e-06 1 2.68055000000001e-06 0 2.68200000000001e-06 0 2.68210000000001e-06 1 2.68650000000001e-06 1 2.68655000000001e-06 0 2.68800000000001e-06 0 2.68810000000001e-06 1 2.69250000000001e-06 1 2.69255000000001e-06 0 2.69400000000001e-06 0 2.69410000000001e-06 1 2.69850000000001e-06 1 2.69855000000001e-06 0 2.70000000000001e-06 0 2.70010000000001e-06 1 2.70450000000001e-06 1 2.70455000000001e-06 0 2.70600000000001e-06 0 2.70610000000001e-06 1 2.71050000000001e-06 1 2.71055000000001e-06 0 2.71200000000001e-06 0 2.71210000000001e-06 1 2.71650000000001e-06 1 2.71655000000001e-06 0 2.71800000000001e-06 0 2.71810000000001e-06 1 2.72250000000001e-06 1 2.72255000000001e-06 0 2.72400000000001e-06 0 2.72410000000001e-06 1 2.72850000000001e-06 1 2.72855000000001e-06 0 2.73000000000001e-06 0 2.73010000000001e-06 1 2.73450000000001e-06 1 2.73455000000001e-06 0 2.73600000000001e-06 0 2.73610000000001e-06 1 2.74050000000001e-06 1 2.74055000000001e-06 0 2.74200000000001e-06 0 2.74210000000001e-06 1 2.74650000000001e-06 1 2.74655000000001e-06 0 2.74800000000001e-06 0 2.74810000000001e-06 1 2.75250000000001e-06 1 2.75255000000001e-06 0 2.75400000000001e-06 0 2.75410000000001e-06 1 2.75850000000001e-06 1 2.75855000000001e-06 0 2.76000000000001e-06 0 2.76010000000001e-06 1 2.76450000000001e-06 1 2.76455000000001e-06 0 2.76600000000001e-06 0 2.76610000000001e-06 1 2.77050000000001e-06 1 2.77055000000001e-06 0 2.77200000000001e-06 0 2.77210000000001e-06 1 2.77650000000001e-06 1 2.77655000000001e-06 0 2.77800000000001e-06 0 2.77810000000001e-06 1 2.78250000000001e-06 1 2.78255000000001e-06 0 2.78400000000001e-06 0 2.78410000000001e-06 1 2.78850000000001e-06 1 2.78855000000001e-06 0 2.79000000000001e-06 0 2.79010000000001e-06 1 2.79450000000001e-06 1 2.79455000000001e-06 0 2.79600000000001e-06 0 2.79610000000001e-06 1 2.80050000000001e-06 1 2.80055000000001e-06 0 2.80200000000001e-06 0 2.80210000000001e-06 1 2.80650000000001e-06 1 2.80655000000001e-06 0 2.80800000000001e-06 0 2.80810000000001e-06 1 2.81250000000001e-06 1 2.81255000000001e-06 0 2.81400000000001e-06 0 2.81410000000001e-06 1 2.81850000000001e-06 1 2.81855000000001e-06 0 2.82000000000001e-06 0 2.82010000000001e-06 1 2.82450000000001e-06 1 2.82455000000001e-06 0 2.82600000000001e-06 0 2.82610000000001e-06 1 2.83050000000001e-06 1 2.83055000000001e-06 0 2.83200000000001e-06 0 2.83210000000001e-06 1 2.83650000000001e-06 1 2.83655000000001e-06 0 2.83800000000001e-06 0 2.83810000000001e-06 1 2.84250000000001e-06 1 2.84255000000001e-06 0 2.84400000000001e-06 0 2.84410000000001e-06 1 2.84850000000001e-06 1 2.84855000000001e-06 0 2.85000000000001e-06 0 2.85010000000001e-06 1 2.85450000000001e-06 1 2.85455000000001e-06 0 2.85600000000001e-06 0 2.85610000000001e-06 1 2.86050000000001e-06 1 2.86055000000001e-06 0 2.86200000000001e-06 0 2.86210000000001e-06 1 2.86650000000001e-06 1 2.86655000000001e-06 0 2.86800000000001e-06 0 2.86810000000001e-06 1 2.87250000000001e-06 1 2.87255000000001e-06 0 2.87400000000001e-06 0 2.87410000000001e-06 1 2.87850000000001e-06 1 2.87855000000001e-06 0 2.88000000000001e-06 0 2.88010000000001e-06 1 2.88450000000001e-06 1 2.88455000000001e-06 0 2.88600000000001e-06 0 2.88610000000001e-06 1 2.89050000000001e-06 1 2.89055000000001e-06 0 2.89200000000001e-06 0 2.89210000000001e-06 1 2.89650000000001e-06 1 2.89655000000001e-06 0 2.89800000000001e-06 0 2.89810000000001e-06 1 2.90250000000001e-06 1 2.90255000000001e-06 0 2.90400000000001e-06 0 2.90410000000001e-06 1 2.90850000000001e-06 1 2.90855000000001e-06 0 2.91000000000001e-06 0 2.91010000000001e-06 1 2.91450000000001e-06 1 2.91455000000001e-06 0 2.91600000000001e-06 0 2.91610000000001e-06 1 2.92050000000001e-06 1 2.92055000000001e-06 0 2.92200000000001e-06 0 2.92210000000001e-06 1 2.92650000000001e-06 1 2.92655000000001e-06 0 2.92800000000001e-06 0 2.92810000000001e-06 1 2.93250000000001e-06 1 2.93255000000001e-06 0 2.93400000000001e-06 0 2.93410000000001e-06 1 2.93850000000001e-06 1 2.93855000000001e-06 0 2.94000000000001e-06 0 2.94010000000001e-06 1 2.94450000000001e-06 1 2.94455000000001e-06 0 2.94600000000001e-06 0 2.94610000000001e-06 1 2.95050000000001e-06 1 2.95055000000001e-06 0 2.95200000000001e-06 0 2.95210000000001e-06 1 2.95650000000001e-06 1 2.95655000000001e-06 0 2.95800000000001e-06 0 2.95810000000001e-06 1 2.96250000000001e-06 1 2.96255000000001e-06 0 2.96400000000001e-06 0 2.96410000000001e-06 1 2.96850000000001e-06 1 2.96855000000001e-06 0 2.97000000000001e-06 0 2.97010000000001e-06 1 2.97450000000001e-06 1 2.97455000000001e-06 0 2.97600000000001e-06 0 2.97610000000001e-06 1 2.98050000000001e-06 1 2.98055000000001e-06 0 2.98200000000001e-06 0 2.98210000000001e-06 1 2.98650000000001e-06 1 2.98655000000001e-06 0 2.98800000000001e-06 0 2.98810000000001e-06 1 2.99250000000001e-06 1 2.99255000000001e-06 0 2.99400000000001e-06 0 2.99410000000001e-06 1 2.99850000000001e-06 1 2.99855000000001e-06 0 3.00000000000001e-06 0 3.00010000000001e-06 1 3.00450000000001e-06 1 3.00455000000001e-06 0 3.00600000000001e-06 0 3.00610000000001e-06 1 3.01050000000001e-06 1 3.01055000000001e-06 0 3.01200000000001e-06 0 3.01210000000001e-06 1 3.01650000000001e-06 1 3.01655000000001e-06 0 3.01800000000001e-06 0 3.01810000000001e-06 1 3.02250000000001e-06 1 3.02255000000001e-06 0 3.02400000000001e-06 0 3.02410000000001e-06 1 3.02850000000001e-06 1 3.02855000000001e-06 0 3.03000000000001e-06 0 3.03010000000001e-06 1 3.03450000000001e-06 1 3.03455000000001e-06 0 3.03600000000001e-06 0 3.03610000000001e-06 1 3.04050000000001e-06 1 3.04055000000001e-06 0 3.04200000000001e-06 0 3.04210000000001e-06 1 3.04650000000001e-06 1 3.04655000000001e-06 0 3.04800000000001e-06 0 3.04810000000001e-06 1 3.05250000000001e-06 1 3.05255000000001e-06 0 3.05400000000001e-06 0 3.05410000000001e-06 1 3.05850000000001e-06 1 3.05855000000001e-06 0 3.06000000000001e-06 0 3.06010000000001e-06 1 3.06450000000001e-06 1 3.06455000000001e-06 0 3.06600000000001e-06 0 3.06610000000001e-06 1 3.07050000000001e-06 1 3.07055000000001e-06 0 3.07190000000001e-06 0 3.07200000000001e-06 1 3.07740000000001e-06 1]
