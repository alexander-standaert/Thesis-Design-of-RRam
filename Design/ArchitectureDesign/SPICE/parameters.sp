simulator lang=spectre

parameters PWmin = 100n                         //MinimalTransistorWidth
parameters PLmin = 45n                          //MinimalTransistorLenght
parameters WChargeBL = 1e-07         //BitLineChargerWidth(perBL)
parameters WDischargeBL = 5e-07   //BitLineDischargerWidth(perBL)
parameters WDischargeSL = 5e-07   //SourceLineDischargerWidth(perBL)
parameters Cpar = 0.18e-15                      //ParasiticCapacitor(perCell)
parameters PWn = 1e-07                     //DifferentialNpairWidth(perSA)
parameters PWp = 1e-07                     //DifferentialPpairWidth(perSA)
parameters PWpenable = 1e-07         //SenseAmpEnablePWidth(perSA)
parameters PWnenable = 1e-07         //SenseAmpEnableNWidth(perSA)
parameters PWmuxLB = 2e-07                //PassgateWidth(perMuxLB)
parameters PWmuxGB = 2e-07                //PassgateWidth(perMuxGB)

parameters numberofruns = 1
parameters enableMismatch = 0   //Mismatch
parameters simlength = 9.6e-08

parameters RMEMHigh = 7500;
parameters RMEMLow = 32500;

parameters Rcell_0_0_0_0 = RMEMHigh
parameters Rcell_0_0_0_1 = RMEMLow
parameters Rcell_0_0_1_0 = RMEMLow
parameters Rcell_0_0_1_1 = RMEMLow
parameters Rcell_0_0_2_0 = RMEMLow
parameters Rcell_0_0_2_1 = RMEMHigh
parameters Rcell_0_0_3_0 = RMEMLow
parameters Rcell_0_0_3_1 = RMEMHigh
parameters Rcell_0_1_0_0 = RMEMLow
parameters Rcell_0_1_0_1 = RMEMHigh
parameters Rcell_0_1_1_0 = RMEMLow
parameters Rcell_0_1_1_1 = RMEMHigh
parameters Rcell_0_1_2_0 = RMEMHigh
parameters Rcell_0_1_2_1 = RMEMHigh
parameters Rcell_0_1_3_0 = RMEMLow
parameters Rcell_0_1_3_1 = RMEMLow

parameters Rref_0 = RMEMHigh
parameters Rref_1 = RMEMLow

parameters waveEnGB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 1.005e-07 0]
parameters waveEnLB_0=[0 0 1e-09 0 1.1e-09 1 5e-09 1 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.105e-08 0 9.5e-08 0 9.505e-08 0 1.005e-07 0]
parameters waveEnLB_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.305e-08 0 4.7e-08 0 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.91e-08 1 5.3e-08 1 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 1.005e-07 0]
parameters waveBLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.31e-08 1 1.7e-08 1 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.105e-08 0 3.5e-08 0 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.11e-08 1 6.5e-08 1 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.905e-08 0 8.3e-08 0 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 1.005e-07 0]
parameters waveBLstart_1=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.05e-09 0 1.1e-08 0 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.905e-08 0 2.3e-08 0 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.51e-08 1 2.9e-08 1 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.71e-08 1 4.1e-08 1 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.505e-08 0 5.9e-08 0 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.705e-08 0 7.1e-08 0 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.31e-08 1 7.7e-08 1 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.51e-08 1 8.9e-08 1 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 1.005e-07 0]
parameters waveWLstart_0=[0 0 1e-09 0 1.05e-09 0 5e-09 0 5.05e-09 0 6e-09 0 6.05e-09 0 7e-09 0 7.1e-09 1 1.1e-08 1 1.105e-08 0 1.2e-08 0 1.205e-08 0 1.3e-08 0 1.305e-08 0 1.7e-08 0 1.705e-08 0 1.8e-08 0 1.805e-08 0 1.9e-08 0 1.91e-08 1 2.3e-08 1 2.305e-08 0 2.4e-08 0 2.405e-08 0 2.5e-08 0 2.505e-08 0 2.9e-08 0 2.905e-08 0 3e-08 0 3.005e-08 0 3.1e-08 0 3.11e-08 1 3.5e-08 1 3.505e-08 0 3.6e-08 0 3.605e-08 0 3.7e-08 0 3.705e-08 0 4.1e-08 0 4.105e-08 0 4.2e-08 0 4.205e-08 0 4.3e-08 0 4.31e-08 1 4.7e-08 1 4.705e-08 0 4.8e-08 0 4.805e-08 0 4.9e-08 0 4.905e-08 0 5.3e-08 0 5.305e-08 0 5.4e-08 0 5.405e-08 0 5.5e-08 0 5.51e-08 1 5.9e-08 1 5.905e-08 0 6e-08 0 6.005e-08 0 6.1e-08 0 6.105e-08 0 6.5e-08 0 6.505e-08 0 6.6e-08 0 6.605e-08 0 6.7e-08 0 6.71e-08 1 7.1e-08 1 7.105e-08 0 7.2e-08 0 7.205e-08 0 7.3e-08 0 7.305e-08 0 7.7e-08 0 7.705e-08 0 7.8e-08 0 7.805e-08 0 7.9e-08 0 7.91e-08 1 8.3e-08 1 8.305e-08 0 8.4e-08 0 8.405e-08 0 8.5e-08 0 8.505e-08 0 8.9e-08 0 8.905e-08 0 9e-08 0 9.005e-08 0 9.1e-08 0 9.11e-08 1 9.5e-08 1 9.505e-08 0 1.005e-07 0]
