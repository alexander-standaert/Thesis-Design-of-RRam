simulator lang=spectre

include "CMOSlogic.scs"
