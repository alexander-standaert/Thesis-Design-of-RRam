simulator lang=spectre

include "localblock.sp"
include "senseamplifier.scs"

subckt globalblock (vdd vss NBulkLine PBulkLine
+LWLencoded_0_0 LWLencoded_0_1 LWLencoded_0_2 LWLencoded_0_3 LWLencoded_0_4 LWLencoded_0_5 LWLencoded_1_0 LWLencoded_1_1 LWLencoded_1_2 LWLencoded_1_3 LWLencoded_1_4 LWLencoded_1_5
+LBLencoded_0_0 LBLencoded_0_1 LBLencoded_1_0 LBLencoded_1_1
+SelLB_0 SelLB_1
+InOut InOutbar EnableSAP EnableSAN
+RefWL_0 RefWL_1 RefWL_2 RefWL_3 RefWL_4 RefWL_5 RefWL_6 RefWL_7 RefWL_8 RefWL_9 RefWL_10 RefWL_11 RefWL_12 RefWL_13 RefWL_14 RefWL_15 RefWL_16 RefWL_17 RefWL_18 RefWL_19 RefWL_20 RefWL_21 RefWL_22 RefWL_23 RefWL_24 RefWL_25 RefWL_26 RefWL_27 RefWL_28 RefWL_29 RefWL_30 RefWL_31 RefWL_32 RefWL_33 RefWL_34 RefWL_35 RefWL_36 RefWL_37 RefWL_38 RefWL_39 RefWL_40 RefWL_41 RefWL_42 RefWL_43 RefWL_44 RefWL_45 RefWL_46 RefWL_47 RefWL_48 RefWL_49 RefWL_50 RefWL_51 RefWL_52 RefWL_53 RefWL_54 RefWL_55 RefWL_56 RefWL_57 RefWL_58 RefWL_59 RefWL_60 RefWL_61 RefWL_62 RefWL_63 RefSourceSelect RefCharge RefDischarge PassRef Delay)
parameters Rcell_0_0_0 Rcell_0_0_1 Rcell_0_0_2 Rcell_0_0_3 Rcell_0_0_4 Rcell_0_0_5 Rcell_0_0_6 Rcell_0_0_7 Rcell_0_0_8 Rcell_0_0_9 Rcell_0_0_10 Rcell_0_0_11 Rcell_0_0_12 Rcell_0_0_13 Rcell_0_0_14 Rcell_0_0_15 Rcell_0_0_16 Rcell_0_0_17 Rcell_0_0_18 Rcell_0_0_19 Rcell_0_0_20 Rcell_0_0_21 Rcell_0_0_22 Rcell_0_0_23 Rcell_0_0_24 Rcell_0_0_25 Rcell_0_0_26 Rcell_0_0_27 Rcell_0_0_28 Rcell_0_0_29 Rcell_0_0_30 Rcell_0_0_31 Rcell_0_0_32 Rcell_0_0_33 Rcell_0_0_34 Rcell_0_0_35 Rcell_0_0_36 Rcell_0_0_37 Rcell_0_0_38 Rcell_0_0_39 Rcell_0_0_40 Rcell_0_0_41 Rcell_0_0_42 Rcell_0_0_43 Rcell_0_0_44 Rcell_0_0_45 Rcell_0_0_46 Rcell_0_0_47 Rcell_0_0_48 Rcell_0_0_49 Rcell_0_0_50 Rcell_0_0_51 Rcell_0_0_52 Rcell_0_0_53 Rcell_0_0_54 Rcell_0_0_55 Rcell_0_0_56 Rcell_0_0_57 Rcell_0_0_58 Rcell_0_0_59 Rcell_0_0_60 Rcell_0_0_61 Rcell_0_0_62 Rcell_0_0_63 Rcell_0_1_0 Rcell_0_1_1 Rcell_0_1_2 Rcell_0_1_3 Rcell_0_1_4 Rcell_0_1_5 Rcell_0_1_6 Rcell_0_1_7 Rcell_0_1_8 Rcell_0_1_9 Rcell_0_1_10 Rcell_0_1_11 Rcell_0_1_12 Rcell_0_1_13 Rcell_0_1_14 Rcell_0_1_15 Rcell_0_1_16 Rcell_0_1_17 Rcell_0_1_18 Rcell_0_1_19 Rcell_0_1_20 Rcell_0_1_21 Rcell_0_1_22 Rcell_0_1_23 Rcell_0_1_24 Rcell_0_1_25 Rcell_0_1_26 Rcell_0_1_27 Rcell_0_1_28 Rcell_0_1_29 Rcell_0_1_30 Rcell_0_1_31 Rcell_0_1_32 Rcell_0_1_33 Rcell_0_1_34 Rcell_0_1_35 Rcell_0_1_36 Rcell_0_1_37 Rcell_0_1_38 Rcell_0_1_39 Rcell_0_1_40 Rcell_0_1_41 Rcell_0_1_42 Rcell_0_1_43 Rcell_0_1_44 Rcell_0_1_45 Rcell_0_1_46 Rcell_0_1_47 Rcell_0_1_48 Rcell_0_1_49 Rcell_0_1_50 Rcell_0_1_51 Rcell_0_1_52 Rcell_0_1_53 Rcell_0_1_54 Rcell_0_1_55 Rcell_0_1_56 Rcell_0_1_57 Rcell_0_1_58 Rcell_0_1_59 Rcell_0_1_60 Rcell_0_1_61 Rcell_0_1_62 Rcell_0_1_63 Rcell_0_2_0 Rcell_0_2_1 Rcell_0_2_2 Rcell_0_2_3 Rcell_0_2_4 Rcell_0_2_5 Rcell_0_2_6 Rcell_0_2_7 Rcell_0_2_8 Rcell_0_2_9 Rcell_0_2_10 Rcell_0_2_11 Rcell_0_2_12 Rcell_0_2_13 Rcell_0_2_14 Rcell_0_2_15 Rcell_0_2_16 Rcell_0_2_17 Rcell_0_2_18 Rcell_0_2_19 Rcell_0_2_20 Rcell_0_2_21 Rcell_0_2_22 Rcell_0_2_23 Rcell_0_2_24 Rcell_0_2_25 Rcell_0_2_26 Rcell_0_2_27 Rcell_0_2_28 Rcell_0_2_29 Rcell_0_2_30 Rcell_0_2_31 Rcell_0_2_32 Rcell_0_2_33 Rcell_0_2_34 Rcell_0_2_35 Rcell_0_2_36 Rcell_0_2_37 Rcell_0_2_38 Rcell_0_2_39 Rcell_0_2_40 Rcell_0_2_41 Rcell_0_2_42 Rcell_0_2_43 Rcell_0_2_44 Rcell_0_2_45 Rcell_0_2_46 Rcell_0_2_47 Rcell_0_2_48 Rcell_0_2_49 Rcell_0_2_50 Rcell_0_2_51 Rcell_0_2_52 Rcell_0_2_53 Rcell_0_2_54 Rcell_0_2_55 Rcell_0_2_56 Rcell_0_2_57 Rcell_0_2_58 Rcell_0_2_59 Rcell_0_2_60 Rcell_0_2_61 Rcell_0_2_62 Rcell_0_2_63 Rcell_0_3_0 Rcell_0_3_1 Rcell_0_3_2 Rcell_0_3_3 Rcell_0_3_4 Rcell_0_3_5 Rcell_0_3_6 Rcell_0_3_7 Rcell_0_3_8 Rcell_0_3_9 Rcell_0_3_10 Rcell_0_3_11 Rcell_0_3_12 Rcell_0_3_13 Rcell_0_3_14 Rcell_0_3_15 Rcell_0_3_16 Rcell_0_3_17 Rcell_0_3_18 Rcell_0_3_19 Rcell_0_3_20 Rcell_0_3_21 Rcell_0_3_22 Rcell_0_3_23 Rcell_0_3_24 Rcell_0_3_25 Rcell_0_3_26 Rcell_0_3_27 Rcell_0_3_28 Rcell_0_3_29 Rcell_0_3_30 Rcell_0_3_31 Rcell_0_3_32 Rcell_0_3_33 Rcell_0_3_34 Rcell_0_3_35 Rcell_0_3_36 Rcell_0_3_37 Rcell_0_3_38 Rcell_0_3_39 Rcell_0_3_40 Rcell_0_3_41 Rcell_0_3_42 Rcell_0_3_43 Rcell_0_3_44 Rcell_0_3_45 Rcell_0_3_46 Rcell_0_3_47 Rcell_0_3_48 Rcell_0_3_49 Rcell_0_3_50 Rcell_0_3_51 Rcell_0_3_52 Rcell_0_3_53 Rcell_0_3_54 Rcell_0_3_55 Rcell_0_3_56 Rcell_0_3_57 Rcell_0_3_58 Rcell_0_3_59 Rcell_0_3_60 Rcell_0_3_61 Rcell_0_3_62 Rcell_0_3_63 Rcell_1_0_0 Rcell_1_0_1 Rcell_1_0_2 Rcell_1_0_3 Rcell_1_0_4 Rcell_1_0_5 Rcell_1_0_6 Rcell_1_0_7 Rcell_1_0_8 Rcell_1_0_9 Rcell_1_0_10 Rcell_1_0_11 Rcell_1_0_12 Rcell_1_0_13 Rcell_1_0_14 Rcell_1_0_15 Rcell_1_0_16 Rcell_1_0_17 Rcell_1_0_18 Rcell_1_0_19 Rcell_1_0_20 Rcell_1_0_21 Rcell_1_0_22 Rcell_1_0_23 Rcell_1_0_24 Rcell_1_0_25 Rcell_1_0_26 Rcell_1_0_27 Rcell_1_0_28 Rcell_1_0_29 Rcell_1_0_30 Rcell_1_0_31 Rcell_1_0_32 Rcell_1_0_33 Rcell_1_0_34 Rcell_1_0_35 Rcell_1_0_36 Rcell_1_0_37 Rcell_1_0_38 Rcell_1_0_39 Rcell_1_0_40 Rcell_1_0_41 Rcell_1_0_42 Rcell_1_0_43 Rcell_1_0_44 Rcell_1_0_45 Rcell_1_0_46 Rcell_1_0_47 Rcell_1_0_48 Rcell_1_0_49 Rcell_1_0_50 Rcell_1_0_51 Rcell_1_0_52 Rcell_1_0_53 Rcell_1_0_54 Rcell_1_0_55 Rcell_1_0_56 Rcell_1_0_57 Rcell_1_0_58 Rcell_1_0_59 Rcell_1_0_60 Rcell_1_0_61 Rcell_1_0_62 Rcell_1_0_63 Rcell_1_1_0 Rcell_1_1_1 Rcell_1_1_2 Rcell_1_1_3 Rcell_1_1_4 Rcell_1_1_5 Rcell_1_1_6 Rcell_1_1_7 Rcell_1_1_8 Rcell_1_1_9 Rcell_1_1_10 Rcell_1_1_11 Rcell_1_1_12 Rcell_1_1_13 Rcell_1_1_14 Rcell_1_1_15 Rcell_1_1_16 Rcell_1_1_17 Rcell_1_1_18 Rcell_1_1_19 Rcell_1_1_20 Rcell_1_1_21 Rcell_1_1_22 Rcell_1_1_23 Rcell_1_1_24 Rcell_1_1_25 Rcell_1_1_26 Rcell_1_1_27 Rcell_1_1_28 Rcell_1_1_29 Rcell_1_1_30 Rcell_1_1_31 Rcell_1_1_32 Rcell_1_1_33 Rcell_1_1_34 Rcell_1_1_35 Rcell_1_1_36 Rcell_1_1_37 Rcell_1_1_38 Rcell_1_1_39 Rcell_1_1_40 Rcell_1_1_41 Rcell_1_1_42 Rcell_1_1_43 Rcell_1_1_44 Rcell_1_1_45 Rcell_1_1_46 Rcell_1_1_47 Rcell_1_1_48 Rcell_1_1_49 Rcell_1_1_50 Rcell_1_1_51 Rcell_1_1_52 Rcell_1_1_53 Rcell_1_1_54 Rcell_1_1_55 Rcell_1_1_56 Rcell_1_1_57 Rcell_1_1_58 Rcell_1_1_59 Rcell_1_1_60 Rcell_1_1_61 Rcell_1_1_62 Rcell_1_1_63 Rcell_1_2_0 Rcell_1_2_1 Rcell_1_2_2 Rcell_1_2_3 Rcell_1_2_4 Rcell_1_2_5 Rcell_1_2_6 Rcell_1_2_7 Rcell_1_2_8 Rcell_1_2_9 Rcell_1_2_10 Rcell_1_2_11 Rcell_1_2_12 Rcell_1_2_13 Rcell_1_2_14 Rcell_1_2_15 Rcell_1_2_16 Rcell_1_2_17 Rcell_1_2_18 Rcell_1_2_19 Rcell_1_2_20 Rcell_1_2_21 Rcell_1_2_22 Rcell_1_2_23 Rcell_1_2_24 Rcell_1_2_25 Rcell_1_2_26 Rcell_1_2_27 Rcell_1_2_28 Rcell_1_2_29 Rcell_1_2_30 Rcell_1_2_31 Rcell_1_2_32 Rcell_1_2_33 Rcell_1_2_34 Rcell_1_2_35 Rcell_1_2_36 Rcell_1_2_37 Rcell_1_2_38 Rcell_1_2_39 Rcell_1_2_40 Rcell_1_2_41 Rcell_1_2_42 Rcell_1_2_43 Rcell_1_2_44 Rcell_1_2_45 Rcell_1_2_46 Rcell_1_2_47 Rcell_1_2_48 Rcell_1_2_49 Rcell_1_2_50 Rcell_1_2_51 Rcell_1_2_52 Rcell_1_2_53 Rcell_1_2_54 Rcell_1_2_55 Rcell_1_2_56 Rcell_1_2_57 Rcell_1_2_58 Rcell_1_2_59 Rcell_1_2_60 Rcell_1_2_61 Rcell_1_2_62 Rcell_1_2_63 Rcell_1_3_0 Rcell_1_3_1 Rcell_1_3_2 Rcell_1_3_3 Rcell_1_3_4 Rcell_1_3_5 Rcell_1_3_6 Rcell_1_3_7 Rcell_1_3_8 Rcell_1_3_9 Rcell_1_3_10 Rcell_1_3_11 Rcell_1_3_12 Rcell_1_3_13 Rcell_1_3_14 Rcell_1_3_15 Rcell_1_3_16 Rcell_1_3_17 Rcell_1_3_18 Rcell_1_3_19 Rcell_1_3_20 Rcell_1_3_21 Rcell_1_3_22 Rcell_1_3_23 Rcell_1_3_24 Rcell_1_3_25 Rcell_1_3_26 Rcell_1_3_27 Rcell_1_3_28 Rcell_1_3_29 Rcell_1_3_30 Rcell_1_3_31 Rcell_1_3_32 Rcell_1_3_33 Rcell_1_3_34 Rcell_1_3_35 Rcell_1_3_36 Rcell_1_3_37 Rcell_1_3_38 Rcell_1_3_39 Rcell_1_3_40 Rcell_1_3_41 Rcell_1_3_42 Rcell_1_3_43 Rcell_1_3_44 Rcell_1_3_45 Rcell_1_3_46 Rcell_1_3_47 Rcell_1_3_48 Rcell_1_3_49 Rcell_1_3_50 Rcell_1_3_51 Rcell_1_3_52 Rcell_1_3_53 Rcell_1_3_54 Rcell_1_3_55 Rcell_1_3_56 Rcell_1_3_57 Rcell_1_3_58 Rcell_1_3_59 Rcell_1_3_60 Rcell_1_3_61 Rcell_1_3_62 Rcell_1_3_63

xLB0 (vdd vss NBulkLine PBulkLine LWLencoded_0_0 LWLencoded_0_1 LWLencoded_0_2 LWLencoded_0_3 LWLencoded_0_4 LWLencoded_0_5 SelLB_0 LBLencoded_0_0 LBLencoded_0_1 SelLB_0 BLout_0 Delay) localblock Rcell_0_0 = Rcell_0_0_0 Rcell_0_1 = Rcell_0_0_1 Rcell_0_2 = Rcell_0_0_2 Rcell_0_3 = Rcell_0_0_3 Rcell_0_4 = Rcell_0_0_4 Rcell_0_5 = Rcell_0_0_5 Rcell_0_6 = Rcell_0_0_6 Rcell_0_7 = Rcell_0_0_7 Rcell_0_8 = Rcell_0_0_8 Rcell_0_9 = Rcell_0_0_9 Rcell_0_10 = Rcell_0_0_10 Rcell_0_11 = Rcell_0_0_11 Rcell_0_12 = Rcell_0_0_12 Rcell_0_13 = Rcell_0_0_13 Rcell_0_14 = Rcell_0_0_14 Rcell_0_15 = Rcell_0_0_15 Rcell_0_16 = Rcell_0_0_16 Rcell_0_17 = Rcell_0_0_17 Rcell_0_18 = Rcell_0_0_18 Rcell_0_19 = Rcell_0_0_19 Rcell_0_20 = Rcell_0_0_20 Rcell_0_21 = Rcell_0_0_21 Rcell_0_22 = Rcell_0_0_22 Rcell_0_23 = Rcell_0_0_23 Rcell_0_24 = Rcell_0_0_24 Rcell_0_25 = Rcell_0_0_25 Rcell_0_26 = Rcell_0_0_26 Rcell_0_27 = Rcell_0_0_27 Rcell_0_28 = Rcell_0_0_28 Rcell_0_29 = Rcell_0_0_29 Rcell_0_30 = Rcell_0_0_30 Rcell_0_31 = Rcell_0_0_31 Rcell_0_32 = Rcell_0_0_32 Rcell_0_33 = Rcell_0_0_33 Rcell_0_34 = Rcell_0_0_34 Rcell_0_35 = Rcell_0_0_35 Rcell_0_36 = Rcell_0_0_36 Rcell_0_37 = Rcell_0_0_37 Rcell_0_38 = Rcell_0_0_38 Rcell_0_39 = Rcell_0_0_39 Rcell_0_40 = Rcell_0_0_40 Rcell_0_41 = Rcell_0_0_41 Rcell_0_42 = Rcell_0_0_42 Rcell_0_43 = Rcell_0_0_43 Rcell_0_44 = Rcell_0_0_44 Rcell_0_45 = Rcell_0_0_45 Rcell_0_46 = Rcell_0_0_46 Rcell_0_47 = Rcell_0_0_47 Rcell_0_48 = Rcell_0_0_48 Rcell_0_49 = Rcell_0_0_49 Rcell_0_50 = Rcell_0_0_50 Rcell_0_51 = Rcell_0_0_51 Rcell_0_52 = Rcell_0_0_52 Rcell_0_53 = Rcell_0_0_53 Rcell_0_54 = Rcell_0_0_54 Rcell_0_55 = Rcell_0_0_55 Rcell_0_56 = Rcell_0_0_56 Rcell_0_57 = Rcell_0_0_57 Rcell_0_58 = Rcell_0_0_58 Rcell_0_59 = Rcell_0_0_59 Rcell_0_60 = Rcell_0_0_60 Rcell_0_61 = Rcell_0_0_61 Rcell_0_62 = Rcell_0_0_62 Rcell_0_63 = Rcell_0_0_63 Rcell_1_0 = Rcell_0_1_0 Rcell_1_1 = Rcell_0_1_1 Rcell_1_2 = Rcell_0_1_2 Rcell_1_3 = Rcell_0_1_3 Rcell_1_4 = Rcell_0_1_4 Rcell_1_5 = Rcell_0_1_5 Rcell_1_6 = Rcell_0_1_6 Rcell_1_7 = Rcell_0_1_7 Rcell_1_8 = Rcell_0_1_8 Rcell_1_9 = Rcell_0_1_9 Rcell_1_10 = Rcell_0_1_10 Rcell_1_11 = Rcell_0_1_11 Rcell_1_12 = Rcell_0_1_12 Rcell_1_13 = Rcell_0_1_13 Rcell_1_14 = Rcell_0_1_14 Rcell_1_15 = Rcell_0_1_15 Rcell_1_16 = Rcell_0_1_16 Rcell_1_17 = Rcell_0_1_17 Rcell_1_18 = Rcell_0_1_18 Rcell_1_19 = Rcell_0_1_19 Rcell_1_20 = Rcell_0_1_20 Rcell_1_21 = Rcell_0_1_21 Rcell_1_22 = Rcell_0_1_22 Rcell_1_23 = Rcell_0_1_23 Rcell_1_24 = Rcell_0_1_24 Rcell_1_25 = Rcell_0_1_25 Rcell_1_26 = Rcell_0_1_26 Rcell_1_27 = Rcell_0_1_27 Rcell_1_28 = Rcell_0_1_28 Rcell_1_29 = Rcell_0_1_29 Rcell_1_30 = Rcell_0_1_30 Rcell_1_31 = Rcell_0_1_31 Rcell_1_32 = Rcell_0_1_32 Rcell_1_33 = Rcell_0_1_33 Rcell_1_34 = Rcell_0_1_34 Rcell_1_35 = Rcell_0_1_35 Rcell_1_36 = Rcell_0_1_36 Rcell_1_37 = Rcell_0_1_37 Rcell_1_38 = Rcell_0_1_38 Rcell_1_39 = Rcell_0_1_39 Rcell_1_40 = Rcell_0_1_40 Rcell_1_41 = Rcell_0_1_41 Rcell_1_42 = Rcell_0_1_42 Rcell_1_43 = Rcell_0_1_43 Rcell_1_44 = Rcell_0_1_44 Rcell_1_45 = Rcell_0_1_45 Rcell_1_46 = Rcell_0_1_46 Rcell_1_47 = Rcell_0_1_47 Rcell_1_48 = Rcell_0_1_48 Rcell_1_49 = Rcell_0_1_49 Rcell_1_50 = Rcell_0_1_50 Rcell_1_51 = Rcell_0_1_51 Rcell_1_52 = Rcell_0_1_52 Rcell_1_53 = Rcell_0_1_53 Rcell_1_54 = Rcell_0_1_54 Rcell_1_55 = Rcell_0_1_55 Rcell_1_56 = Rcell_0_1_56 Rcell_1_57 = Rcell_0_1_57 Rcell_1_58 = Rcell_0_1_58 Rcell_1_59 = Rcell_0_1_59 Rcell_1_60 = Rcell_0_1_60 Rcell_1_61 = Rcell_0_1_61 Rcell_1_62 = Rcell_0_1_62 Rcell_1_63 = Rcell_0_1_63 Rcell_2_0 = Rcell_0_2_0 Rcell_2_1 = Rcell_0_2_1 Rcell_2_2 = Rcell_0_2_2 Rcell_2_3 = Rcell_0_2_3 Rcell_2_4 = Rcell_0_2_4 Rcell_2_5 = Rcell_0_2_5 Rcell_2_6 = Rcell_0_2_6 Rcell_2_7 = Rcell_0_2_7 Rcell_2_8 = Rcell_0_2_8 Rcell_2_9 = Rcell_0_2_9 Rcell_2_10 = Rcell_0_2_10 Rcell_2_11 = Rcell_0_2_11 Rcell_2_12 = Rcell_0_2_12 Rcell_2_13 = Rcell_0_2_13 Rcell_2_14 = Rcell_0_2_14 Rcell_2_15 = Rcell_0_2_15 Rcell_2_16 = Rcell_0_2_16 Rcell_2_17 = Rcell_0_2_17 Rcell_2_18 = Rcell_0_2_18 Rcell_2_19 = Rcell_0_2_19 Rcell_2_20 = Rcell_0_2_20 Rcell_2_21 = Rcell_0_2_21 Rcell_2_22 = Rcell_0_2_22 Rcell_2_23 = Rcell_0_2_23 Rcell_2_24 = Rcell_0_2_24 Rcell_2_25 = Rcell_0_2_25 Rcell_2_26 = Rcell_0_2_26 Rcell_2_27 = Rcell_0_2_27 Rcell_2_28 = Rcell_0_2_28 Rcell_2_29 = Rcell_0_2_29 Rcell_2_30 = Rcell_0_2_30 Rcell_2_31 = Rcell_0_2_31 Rcell_2_32 = Rcell_0_2_32 Rcell_2_33 = Rcell_0_2_33 Rcell_2_34 = Rcell_0_2_34 Rcell_2_35 = Rcell_0_2_35 Rcell_2_36 = Rcell_0_2_36 Rcell_2_37 = Rcell_0_2_37 Rcell_2_38 = Rcell_0_2_38 Rcell_2_39 = Rcell_0_2_39 Rcell_2_40 = Rcell_0_2_40 Rcell_2_41 = Rcell_0_2_41 Rcell_2_42 = Rcell_0_2_42 Rcell_2_43 = Rcell_0_2_43 Rcell_2_44 = Rcell_0_2_44 Rcell_2_45 = Rcell_0_2_45 Rcell_2_46 = Rcell_0_2_46 Rcell_2_47 = Rcell_0_2_47 Rcell_2_48 = Rcell_0_2_48 Rcell_2_49 = Rcell_0_2_49 Rcell_2_50 = Rcell_0_2_50 Rcell_2_51 = Rcell_0_2_51 Rcell_2_52 = Rcell_0_2_52 Rcell_2_53 = Rcell_0_2_53 Rcell_2_54 = Rcell_0_2_54 Rcell_2_55 = Rcell_0_2_55 Rcell_2_56 = Rcell_0_2_56 Rcell_2_57 = Rcell_0_2_57 Rcell_2_58 = Rcell_0_2_58 Rcell_2_59 = Rcell_0_2_59 Rcell_2_60 = Rcell_0_2_60 Rcell_2_61 = Rcell_0_2_61 Rcell_2_62 = Rcell_0_2_62 Rcell_2_63 = Rcell_0_2_63 Rcell_3_0 = Rcell_0_3_0 Rcell_3_1 = Rcell_0_3_1 Rcell_3_2 = Rcell_0_3_2 Rcell_3_3 = Rcell_0_3_3 Rcell_3_4 = Rcell_0_3_4 Rcell_3_5 = Rcell_0_3_5 Rcell_3_6 = Rcell_0_3_6 Rcell_3_7 = Rcell_0_3_7 Rcell_3_8 = Rcell_0_3_8 Rcell_3_9 = Rcell_0_3_9 Rcell_3_10 = Rcell_0_3_10 Rcell_3_11 = Rcell_0_3_11 Rcell_3_12 = Rcell_0_3_12 Rcell_3_13 = Rcell_0_3_13 Rcell_3_14 = Rcell_0_3_14 Rcell_3_15 = Rcell_0_3_15 Rcell_3_16 = Rcell_0_3_16 Rcell_3_17 = Rcell_0_3_17 Rcell_3_18 = Rcell_0_3_18 Rcell_3_19 = Rcell_0_3_19 Rcell_3_20 = Rcell_0_3_20 Rcell_3_21 = Rcell_0_3_21 Rcell_3_22 = Rcell_0_3_22 Rcell_3_23 = Rcell_0_3_23 Rcell_3_24 = Rcell_0_3_24 Rcell_3_25 = Rcell_0_3_25 Rcell_3_26 = Rcell_0_3_26 Rcell_3_27 = Rcell_0_3_27 Rcell_3_28 = Rcell_0_3_28 Rcell_3_29 = Rcell_0_3_29 Rcell_3_30 = Rcell_0_3_30 Rcell_3_31 = Rcell_0_3_31 Rcell_3_32 = Rcell_0_3_32 Rcell_3_33 = Rcell_0_3_33 Rcell_3_34 = Rcell_0_3_34 Rcell_3_35 = Rcell_0_3_35 Rcell_3_36 = Rcell_0_3_36 Rcell_3_37 = Rcell_0_3_37 Rcell_3_38 = Rcell_0_3_38 Rcell_3_39 = Rcell_0_3_39 Rcell_3_40 = Rcell_0_3_40 Rcell_3_41 = Rcell_0_3_41 Rcell_3_42 = Rcell_0_3_42 Rcell_3_43 = Rcell_0_3_43 Rcell_3_44 = Rcell_0_3_44 Rcell_3_45 = Rcell_0_3_45 Rcell_3_46 = Rcell_0_3_46 Rcell_3_47 = Rcell_0_3_47 Rcell_3_48 = Rcell_0_3_48 Rcell_3_49 = Rcell_0_3_49 Rcell_3_50 = Rcell_0_3_50 Rcell_3_51 = Rcell_0_3_51 Rcell_3_52 = Rcell_0_3_52 Rcell_3_53 = Rcell_0_3_53 Rcell_3_54 = Rcell_0_3_54 Rcell_3_55 = Rcell_0_3_55 Rcell_3_56 = Rcell_0_3_56 Rcell_3_57 = Rcell_0_3_57 Rcell_3_58 = Rcell_0_3_58 Rcell_3_59 = Rcell_0_3_59 Rcell_3_60 = Rcell_0_3_60 Rcell_3_61 = Rcell_0_3_61 Rcell_3_62 = Rcell_0_3_62 Rcell_3_63 = Rcell_0_3_63
xM0 BLout_0 SelLB_0 InOut NBulkLine mc_nmos_lvt w=PWmuxGB l=PLmin
xLB1 (vdd vss NBulkLine PBulkLine LWLencoded_1_0 LWLencoded_1_1 LWLencoded_1_2 LWLencoded_1_3 LWLencoded_1_4 LWLencoded_1_5 SelLB_1 LBLencoded_1_0 LBLencoded_1_1 SelLB_1 BLout_1 Delay) localblock Rcell_0_0 = Rcell_1_0_0 Rcell_0_1 = Rcell_1_0_1 Rcell_0_2 = Rcell_1_0_2 Rcell_0_3 = Rcell_1_0_3 Rcell_0_4 = Rcell_1_0_4 Rcell_0_5 = Rcell_1_0_5 Rcell_0_6 = Rcell_1_0_6 Rcell_0_7 = Rcell_1_0_7 Rcell_0_8 = Rcell_1_0_8 Rcell_0_9 = Rcell_1_0_9 Rcell_0_10 = Rcell_1_0_10 Rcell_0_11 = Rcell_1_0_11 Rcell_0_12 = Rcell_1_0_12 Rcell_0_13 = Rcell_1_0_13 Rcell_0_14 = Rcell_1_0_14 Rcell_0_15 = Rcell_1_0_15 Rcell_0_16 = Rcell_1_0_16 Rcell_0_17 = Rcell_1_0_17 Rcell_0_18 = Rcell_1_0_18 Rcell_0_19 = Rcell_1_0_19 Rcell_0_20 = Rcell_1_0_20 Rcell_0_21 = Rcell_1_0_21 Rcell_0_22 = Rcell_1_0_22 Rcell_0_23 = Rcell_1_0_23 Rcell_0_24 = Rcell_1_0_24 Rcell_0_25 = Rcell_1_0_25 Rcell_0_26 = Rcell_1_0_26 Rcell_0_27 = Rcell_1_0_27 Rcell_0_28 = Rcell_1_0_28 Rcell_0_29 = Rcell_1_0_29 Rcell_0_30 = Rcell_1_0_30 Rcell_0_31 = Rcell_1_0_31 Rcell_0_32 = Rcell_1_0_32 Rcell_0_33 = Rcell_1_0_33 Rcell_0_34 = Rcell_1_0_34 Rcell_0_35 = Rcell_1_0_35 Rcell_0_36 = Rcell_1_0_36 Rcell_0_37 = Rcell_1_0_37 Rcell_0_38 = Rcell_1_0_38 Rcell_0_39 = Rcell_1_0_39 Rcell_0_40 = Rcell_1_0_40 Rcell_0_41 = Rcell_1_0_41 Rcell_0_42 = Rcell_1_0_42 Rcell_0_43 = Rcell_1_0_43 Rcell_0_44 = Rcell_1_0_44 Rcell_0_45 = Rcell_1_0_45 Rcell_0_46 = Rcell_1_0_46 Rcell_0_47 = Rcell_1_0_47 Rcell_0_48 = Rcell_1_0_48 Rcell_0_49 = Rcell_1_0_49 Rcell_0_50 = Rcell_1_0_50 Rcell_0_51 = Rcell_1_0_51 Rcell_0_52 = Rcell_1_0_52 Rcell_0_53 = Rcell_1_0_53 Rcell_0_54 = Rcell_1_0_54 Rcell_0_55 = Rcell_1_0_55 Rcell_0_56 = Rcell_1_0_56 Rcell_0_57 = Rcell_1_0_57 Rcell_0_58 = Rcell_1_0_58 Rcell_0_59 = Rcell_1_0_59 Rcell_0_60 = Rcell_1_0_60 Rcell_0_61 = Rcell_1_0_61 Rcell_0_62 = Rcell_1_0_62 Rcell_0_63 = Rcell_1_0_63 Rcell_1_0 = Rcell_1_1_0 Rcell_1_1 = Rcell_1_1_1 Rcell_1_2 = Rcell_1_1_2 Rcell_1_3 = Rcell_1_1_3 Rcell_1_4 = Rcell_1_1_4 Rcell_1_5 = Rcell_1_1_5 Rcell_1_6 = Rcell_1_1_6 Rcell_1_7 = Rcell_1_1_7 Rcell_1_8 = Rcell_1_1_8 Rcell_1_9 = Rcell_1_1_9 Rcell_1_10 = Rcell_1_1_10 Rcell_1_11 = Rcell_1_1_11 Rcell_1_12 = Rcell_1_1_12 Rcell_1_13 = Rcell_1_1_13 Rcell_1_14 = Rcell_1_1_14 Rcell_1_15 = Rcell_1_1_15 Rcell_1_16 = Rcell_1_1_16 Rcell_1_17 = Rcell_1_1_17 Rcell_1_18 = Rcell_1_1_18 Rcell_1_19 = Rcell_1_1_19 Rcell_1_20 = Rcell_1_1_20 Rcell_1_21 = Rcell_1_1_21 Rcell_1_22 = Rcell_1_1_22 Rcell_1_23 = Rcell_1_1_23 Rcell_1_24 = Rcell_1_1_24 Rcell_1_25 = Rcell_1_1_25 Rcell_1_26 = Rcell_1_1_26 Rcell_1_27 = Rcell_1_1_27 Rcell_1_28 = Rcell_1_1_28 Rcell_1_29 = Rcell_1_1_29 Rcell_1_30 = Rcell_1_1_30 Rcell_1_31 = Rcell_1_1_31 Rcell_1_32 = Rcell_1_1_32 Rcell_1_33 = Rcell_1_1_33 Rcell_1_34 = Rcell_1_1_34 Rcell_1_35 = Rcell_1_1_35 Rcell_1_36 = Rcell_1_1_36 Rcell_1_37 = Rcell_1_1_37 Rcell_1_38 = Rcell_1_1_38 Rcell_1_39 = Rcell_1_1_39 Rcell_1_40 = Rcell_1_1_40 Rcell_1_41 = Rcell_1_1_41 Rcell_1_42 = Rcell_1_1_42 Rcell_1_43 = Rcell_1_1_43 Rcell_1_44 = Rcell_1_1_44 Rcell_1_45 = Rcell_1_1_45 Rcell_1_46 = Rcell_1_1_46 Rcell_1_47 = Rcell_1_1_47 Rcell_1_48 = Rcell_1_1_48 Rcell_1_49 = Rcell_1_1_49 Rcell_1_50 = Rcell_1_1_50 Rcell_1_51 = Rcell_1_1_51 Rcell_1_52 = Rcell_1_1_52 Rcell_1_53 = Rcell_1_1_53 Rcell_1_54 = Rcell_1_1_54 Rcell_1_55 = Rcell_1_1_55 Rcell_1_56 = Rcell_1_1_56 Rcell_1_57 = Rcell_1_1_57 Rcell_1_58 = Rcell_1_1_58 Rcell_1_59 = Rcell_1_1_59 Rcell_1_60 = Rcell_1_1_60 Rcell_1_61 = Rcell_1_1_61 Rcell_1_62 = Rcell_1_1_62 Rcell_1_63 = Rcell_1_1_63 Rcell_2_0 = Rcell_1_2_0 Rcell_2_1 = Rcell_1_2_1 Rcell_2_2 = Rcell_1_2_2 Rcell_2_3 = Rcell_1_2_3 Rcell_2_4 = Rcell_1_2_4 Rcell_2_5 = Rcell_1_2_5 Rcell_2_6 = Rcell_1_2_6 Rcell_2_7 = Rcell_1_2_7 Rcell_2_8 = Rcell_1_2_8 Rcell_2_9 = Rcell_1_2_9 Rcell_2_10 = Rcell_1_2_10 Rcell_2_11 = Rcell_1_2_11 Rcell_2_12 = Rcell_1_2_12 Rcell_2_13 = Rcell_1_2_13 Rcell_2_14 = Rcell_1_2_14 Rcell_2_15 = Rcell_1_2_15 Rcell_2_16 = Rcell_1_2_16 Rcell_2_17 = Rcell_1_2_17 Rcell_2_18 = Rcell_1_2_18 Rcell_2_19 = Rcell_1_2_19 Rcell_2_20 = Rcell_1_2_20 Rcell_2_21 = Rcell_1_2_21 Rcell_2_22 = Rcell_1_2_22 Rcell_2_23 = Rcell_1_2_23 Rcell_2_24 = Rcell_1_2_24 Rcell_2_25 = Rcell_1_2_25 Rcell_2_26 = Rcell_1_2_26 Rcell_2_27 = Rcell_1_2_27 Rcell_2_28 = Rcell_1_2_28 Rcell_2_29 = Rcell_1_2_29 Rcell_2_30 = Rcell_1_2_30 Rcell_2_31 = Rcell_1_2_31 Rcell_2_32 = Rcell_1_2_32 Rcell_2_33 = Rcell_1_2_33 Rcell_2_34 = Rcell_1_2_34 Rcell_2_35 = Rcell_1_2_35 Rcell_2_36 = Rcell_1_2_36 Rcell_2_37 = Rcell_1_2_37 Rcell_2_38 = Rcell_1_2_38 Rcell_2_39 = Rcell_1_2_39 Rcell_2_40 = Rcell_1_2_40 Rcell_2_41 = Rcell_1_2_41 Rcell_2_42 = Rcell_1_2_42 Rcell_2_43 = Rcell_1_2_43 Rcell_2_44 = Rcell_1_2_44 Rcell_2_45 = Rcell_1_2_45 Rcell_2_46 = Rcell_1_2_46 Rcell_2_47 = Rcell_1_2_47 Rcell_2_48 = Rcell_1_2_48 Rcell_2_49 = Rcell_1_2_49 Rcell_2_50 = Rcell_1_2_50 Rcell_2_51 = Rcell_1_2_51 Rcell_2_52 = Rcell_1_2_52 Rcell_2_53 = Rcell_1_2_53 Rcell_2_54 = Rcell_1_2_54 Rcell_2_55 = Rcell_1_2_55 Rcell_2_56 = Rcell_1_2_56 Rcell_2_57 = Rcell_1_2_57 Rcell_2_58 = Rcell_1_2_58 Rcell_2_59 = Rcell_1_2_59 Rcell_2_60 = Rcell_1_2_60 Rcell_2_61 = Rcell_1_2_61 Rcell_2_62 = Rcell_1_2_62 Rcell_2_63 = Rcell_1_2_63 Rcell_3_0 = Rcell_1_3_0 Rcell_3_1 = Rcell_1_3_1 Rcell_3_2 = Rcell_1_3_2 Rcell_3_3 = Rcell_1_3_3 Rcell_3_4 = Rcell_1_3_4 Rcell_3_5 = Rcell_1_3_5 Rcell_3_6 = Rcell_1_3_6 Rcell_3_7 = Rcell_1_3_7 Rcell_3_8 = Rcell_1_3_8 Rcell_3_9 = Rcell_1_3_9 Rcell_3_10 = Rcell_1_3_10 Rcell_3_11 = Rcell_1_3_11 Rcell_3_12 = Rcell_1_3_12 Rcell_3_13 = Rcell_1_3_13 Rcell_3_14 = Rcell_1_3_14 Rcell_3_15 = Rcell_1_3_15 Rcell_3_16 = Rcell_1_3_16 Rcell_3_17 = Rcell_1_3_17 Rcell_3_18 = Rcell_1_3_18 Rcell_3_19 = Rcell_1_3_19 Rcell_3_20 = Rcell_1_3_20 Rcell_3_21 = Rcell_1_3_21 Rcell_3_22 = Rcell_1_3_22 Rcell_3_23 = Rcell_1_3_23 Rcell_3_24 = Rcell_1_3_24 Rcell_3_25 = Rcell_1_3_25 Rcell_3_26 = Rcell_1_3_26 Rcell_3_27 = Rcell_1_3_27 Rcell_3_28 = Rcell_1_3_28 Rcell_3_29 = Rcell_1_3_29 Rcell_3_30 = Rcell_1_3_30 Rcell_3_31 = Rcell_1_3_31 Rcell_3_32 = Rcell_1_3_32 Rcell_3_33 = Rcell_1_3_33 Rcell_3_34 = Rcell_1_3_34 Rcell_3_35 = Rcell_1_3_35 Rcell_3_36 = Rcell_1_3_36 Rcell_3_37 = Rcell_1_3_37 Rcell_3_38 = Rcell_1_3_38 Rcell_3_39 = Rcell_1_3_39 Rcell_3_40 = Rcell_1_3_40 Rcell_3_41 = Rcell_1_3_41 Rcell_3_42 = Rcell_1_3_42 Rcell_3_43 = Rcell_1_3_43 Rcell_3_44 = Rcell_1_3_44 Rcell_3_45 = Rcell_1_3_45 Rcell_3_46 = Rcell_1_3_46 Rcell_3_47 = Rcell_1_3_47 Rcell_3_48 = Rcell_1_3_48 Rcell_3_49 = Rcell_1_3_49 Rcell_3_50 = Rcell_1_3_50 Rcell_3_51 = Rcell_1_3_51 Rcell_3_52 = Rcell_1_3_52 Rcell_3_53 = Rcell_1_3_53 Rcell_3_54 = Rcell_1_3_54 Rcell_3_55 = Rcell_1_3_55 Rcell_3_56 = Rcell_1_3_56 Rcell_3_57 = Rcell_1_3_57 Rcell_3_58 = Rcell_1_3_58 Rcell_3_59 = Rcell_1_3_59 Rcell_3_60 = Rcell_1_3_60 Rcell_3_61 = Rcell_1_3_61 Rcell_3_62 = Rcell_1_3_62 Rcell_3_63 = Rcell_1_3_63
xM1 BLout_1 SelLB_1 InOut NBulkLine mc_nmos_lvt w=PWmuxGB l=PLmin
xRefBranch (vdd vss RefBitLine RefWL_0 RefWL_1 RefWL_2 RefWL_3 RefWL_4 RefWL_5 RefWL_6 RefWL_7 RefWL_8 RefWL_9 RefWL_10 RefWL_11 RefWL_12 RefWL_13 RefWL_14 RefWL_15 RefWL_16 RefWL_17 RefWL_18 RefWL_19 RefWL_20 RefWL_21 RefWL_22 RefWL_23 RefWL_24 RefWL_25 RefWL_26 RefWL_27 RefWL_28 RefWL_29 RefWL_30 RefWL_31 RefWL_32 RefWL_33 RefWL_34 RefWL_35 RefWL_36 RefWL_37 RefWL_38 RefWL_39 RefWL_40 RefWL_41 RefWL_42 RefWL_43 RefWL_44 RefWL_45 RefWL_46 RefWL_47 RefWL_48 RefWL_49 RefWL_50 RefWL_51 RefWL_52 RefWL_53 RefWL_54 RefWL_55 RefWL_56 RefWL_57 RefWL_58 RefWL_59 RefWL_60 RefWL_61 RefWL_62 RefWL_63 RefSourceSelect RefCharge RefDischarge PBulkLine NBulkLine) branch Rcell_0 = Rref_0 Rcell_1 = Rref_1 Rcell_2 = Rref_2 Rcell_3 = Rref_3 Rcell_4 = Rref_4 Rcell_5 = Rref_5 Rcell_6 = Rref_6 Rcell_7 = Rref_7 Rcell_8 = Rref_8 Rcell_9 = Rref_9 Rcell_10 = Rref_10 Rcell_11 = Rref_11 Rcell_12 = Rref_12 Rcell_13 = Rref_13 Rcell_14 = Rref_14 Rcell_15 = Rref_15 Rcell_16 = Rref_16 Rcell_17 = Rref_17 Rcell_18 = Rref_18 Rcell_19 = Rref_19 Rcell_20 = Rref_20 Rcell_21 = Rref_21 Rcell_22 = Rref_22 Rcell_23 = Rref_23 Rcell_24 = Rref_24 Rcell_25 = Rref_25 Rcell_26 = Rref_26 Rcell_27 = Rref_27 Rcell_28 = Rref_28 Rcell_29 = Rref_29 Rcell_30 = Rref_30 Rcell_31 = Rref_31 Rcell_32 = Rref_32 Rcell_33 = Rref_33 Rcell_34 = Rref_34 Rcell_35 = Rref_35 Rcell_36 = Rref_36 Rcell_37 = Rref_37 Rcell_38 = Rref_38 Rcell_39 = Rref_39 Rcell_40 = Rref_40 Rcell_41 = Rref_41 Rcell_42 = Rref_42 Rcell_43 = Rref_43 Rcell_44 = Rref_44 Rcell_45 = Rref_45 Rcell_46 = Rref_46 Rcell_47 = Rref_47 Rcell_48 = Rref_48 Rcell_49 = Rref_49 Rcell_50 = Rref_50 Rcell_51 = Rref_51 Rcell_52 = Rref_52 Rcell_53 = Rref_53 Rcell_54 = Rref_54 Rcell_55 = Rref_55 Rcell_56 = Rref_56 Rcell_57 = Rref_57 Rcell_58 = Rref_58 Rcell_59 = Rref_59 Rcell_60 = Rref_60 Rcell_61 = Rref_61 Rcell_62 = Rref_62 Rcell_63 = Rref_63
xPassgate (RefBitLine PassRef InOutbar NBulkLine) mc_nmos_lvt w=PWmuxGB l=PLmin

xSA (vdd vss NBulkLine PBulkLine InOut InOutbar EnableSAP EnableSAN) senseamplifier

ends globalblock
