simulator lang=spectre

include "localblock.sp"
include "senseamplifier.scs"

subckt globalblock (vdd_0 vdd_1 vdd_2 vdd_3 vss NBulkLine PBulkLine
+LWLencoded_0_0 LWLencoded_0_1 LWLencoded_0_2 LWLencoded_0_3 LWLencoded_1_0 LWLencoded_1_1 LWLencoded_1_2 LWLencoded_1_3
+LBLencoded_0_0 LBLencoded_0_1 LBLencoded_0_2 LBLencoded_0_3 LBLencoded_1_0 LBLencoded_1_1 LBLencoded_1_2 LBLencoded_1_3
+SelLB_0 SelLB_1 LBenbar_0 LBenbar_1 GBenable
+InOut InOutbar SA_SH EnableSAP EnableSAN)
parameters Rcell_0_0_0 Rcell_0_0_1 Rcell_0_0_2 Rcell_0_0_3 Rcell_0_0_4 Rcell_0_0_5 Rcell_0_0_6 Rcell_0_0_7 Rcell_0_0_8 Rcell_0_0_9 Rcell_0_0_10 Rcell_0_0_11 Rcell_0_0_12 Rcell_0_0_13 Rcell_0_0_14 Rcell_0_0_15 Rcell_0_1_0 Rcell_0_1_1 Rcell_0_1_2 Rcell_0_1_3 Rcell_0_1_4 Rcell_0_1_5 Rcell_0_1_6 Rcell_0_1_7 Rcell_0_1_8 Rcell_0_1_9 Rcell_0_1_10 Rcell_0_1_11 Rcell_0_1_12 Rcell_0_1_13 Rcell_0_1_14 Rcell_0_1_15 Rcell_0_2_0 Rcell_0_2_1 Rcell_0_2_2 Rcell_0_2_3 Rcell_0_2_4 Rcell_0_2_5 Rcell_0_2_6 Rcell_0_2_7 Rcell_0_2_8 Rcell_0_2_9 Rcell_0_2_10 Rcell_0_2_11 Rcell_0_2_12 Rcell_0_2_13 Rcell_0_2_14 Rcell_0_2_15 Rcell_0_3_0 Rcell_0_3_1 Rcell_0_3_2 Rcell_0_3_3 Rcell_0_3_4 Rcell_0_3_5 Rcell_0_3_6 Rcell_0_3_7 Rcell_0_3_8 Rcell_0_3_9 Rcell_0_3_10 Rcell_0_3_11 Rcell_0_3_12 Rcell_0_3_13 Rcell_0_3_14 Rcell_0_3_15 Rcell_0_4_0 Rcell_0_4_1 Rcell_0_4_2 Rcell_0_4_3 Rcell_0_4_4 Rcell_0_4_5 Rcell_0_4_6 Rcell_0_4_7 Rcell_0_4_8 Rcell_0_4_9 Rcell_0_4_10 Rcell_0_4_11 Rcell_0_4_12 Rcell_0_4_13 Rcell_0_4_14 Rcell_0_4_15 Rcell_0_5_0 Rcell_0_5_1 Rcell_0_5_2 Rcell_0_5_3 Rcell_0_5_4 Rcell_0_5_5 Rcell_0_5_6 Rcell_0_5_7 Rcell_0_5_8 Rcell_0_5_9 Rcell_0_5_10 Rcell_0_5_11 Rcell_0_5_12 Rcell_0_5_13 Rcell_0_5_14 Rcell_0_5_15 Rcell_0_6_0 Rcell_0_6_1 Rcell_0_6_2 Rcell_0_6_3 Rcell_0_6_4 Rcell_0_6_5 Rcell_0_6_6 Rcell_0_6_7 Rcell_0_6_8 Rcell_0_6_9 Rcell_0_6_10 Rcell_0_6_11 Rcell_0_6_12 Rcell_0_6_13 Rcell_0_6_14 Rcell_0_6_15 Rcell_0_7_0 Rcell_0_7_1 Rcell_0_7_2 Rcell_0_7_3 Rcell_0_7_4 Rcell_0_7_5 Rcell_0_7_6 Rcell_0_7_7 Rcell_0_7_8 Rcell_0_7_9 Rcell_0_7_10 Rcell_0_7_11 Rcell_0_7_12 Rcell_0_7_13 Rcell_0_7_14 Rcell_0_7_15 Rcell_0_8_0 Rcell_0_8_1 Rcell_0_8_2 Rcell_0_8_3 Rcell_0_8_4 Rcell_0_8_5 Rcell_0_8_6 Rcell_0_8_7 Rcell_0_8_8 Rcell_0_8_9 Rcell_0_8_10 Rcell_0_8_11 Rcell_0_8_12 Rcell_0_8_13 Rcell_0_8_14 Rcell_0_8_15 Rcell_0_9_0 Rcell_0_9_1 Rcell_0_9_2 Rcell_0_9_3 Rcell_0_9_4 Rcell_0_9_5 Rcell_0_9_6 Rcell_0_9_7 Rcell_0_9_8 Rcell_0_9_9 Rcell_0_9_10 Rcell_0_9_11 Rcell_0_9_12 Rcell_0_9_13 Rcell_0_9_14 Rcell_0_9_15 Rcell_0_10_0 Rcell_0_10_1 Rcell_0_10_2 Rcell_0_10_3 Rcell_0_10_4 Rcell_0_10_5 Rcell_0_10_6 Rcell_0_10_7 Rcell_0_10_8 Rcell_0_10_9 Rcell_0_10_10 Rcell_0_10_11 Rcell_0_10_12 Rcell_0_10_13 Rcell_0_10_14 Rcell_0_10_15 Rcell_0_11_0 Rcell_0_11_1 Rcell_0_11_2 Rcell_0_11_3 Rcell_0_11_4 Rcell_0_11_5 Rcell_0_11_6 Rcell_0_11_7 Rcell_0_11_8 Rcell_0_11_9 Rcell_0_11_10 Rcell_0_11_11 Rcell_0_11_12 Rcell_0_11_13 Rcell_0_11_14 Rcell_0_11_15 Rcell_0_12_0 Rcell_0_12_1 Rcell_0_12_2 Rcell_0_12_3 Rcell_0_12_4 Rcell_0_12_5 Rcell_0_12_6 Rcell_0_12_7 Rcell_0_12_8 Rcell_0_12_9 Rcell_0_12_10 Rcell_0_12_11 Rcell_0_12_12 Rcell_0_12_13 Rcell_0_12_14 Rcell_0_12_15 Rcell_0_13_0 Rcell_0_13_1 Rcell_0_13_2 Rcell_0_13_3 Rcell_0_13_4 Rcell_0_13_5 Rcell_0_13_6 Rcell_0_13_7 Rcell_0_13_8 Rcell_0_13_9 Rcell_0_13_10 Rcell_0_13_11 Rcell_0_13_12 Rcell_0_13_13 Rcell_0_13_14 Rcell_0_13_15 Rcell_0_14_0 Rcell_0_14_1 Rcell_0_14_2 Rcell_0_14_3 Rcell_0_14_4 Rcell_0_14_5 Rcell_0_14_6 Rcell_0_14_7 Rcell_0_14_8 Rcell_0_14_9 Rcell_0_14_10 Rcell_0_14_11 Rcell_0_14_12 Rcell_0_14_13 Rcell_0_14_14 Rcell_0_14_15 Rcell_0_15_0 Rcell_0_15_1 Rcell_0_15_2 Rcell_0_15_3 Rcell_0_15_4 Rcell_0_15_5 Rcell_0_15_6 Rcell_0_15_7 Rcell_0_15_8 Rcell_0_15_9 Rcell_0_15_10 Rcell_0_15_11 Rcell_0_15_12 Rcell_0_15_13 Rcell_0_15_14 Rcell_0_15_15 Rcell_1_0_0 Rcell_1_0_1 Rcell_1_0_2 Rcell_1_0_3 Rcell_1_0_4 Rcell_1_0_5 Rcell_1_0_6 Rcell_1_0_7 Rcell_1_0_8 Rcell_1_0_9 Rcell_1_0_10 Rcell_1_0_11 Rcell_1_0_12 Rcell_1_0_13 Rcell_1_0_14 Rcell_1_0_15 Rcell_1_1_0 Rcell_1_1_1 Rcell_1_1_2 Rcell_1_1_3 Rcell_1_1_4 Rcell_1_1_5 Rcell_1_1_6 Rcell_1_1_7 Rcell_1_1_8 Rcell_1_1_9 Rcell_1_1_10 Rcell_1_1_11 Rcell_1_1_12 Rcell_1_1_13 Rcell_1_1_14 Rcell_1_1_15 Rcell_1_2_0 Rcell_1_2_1 Rcell_1_2_2 Rcell_1_2_3 Rcell_1_2_4 Rcell_1_2_5 Rcell_1_2_6 Rcell_1_2_7 Rcell_1_2_8 Rcell_1_2_9 Rcell_1_2_10 Rcell_1_2_11 Rcell_1_2_12 Rcell_1_2_13 Rcell_1_2_14 Rcell_1_2_15 Rcell_1_3_0 Rcell_1_3_1 Rcell_1_3_2 Rcell_1_3_3 Rcell_1_3_4 Rcell_1_3_5 Rcell_1_3_6 Rcell_1_3_7 Rcell_1_3_8 Rcell_1_3_9 Rcell_1_3_10 Rcell_1_3_11 Rcell_1_3_12 Rcell_1_3_13 Rcell_1_3_14 Rcell_1_3_15 Rcell_1_4_0 Rcell_1_4_1 Rcell_1_4_2 Rcell_1_4_3 Rcell_1_4_4 Rcell_1_4_5 Rcell_1_4_6 Rcell_1_4_7 Rcell_1_4_8 Rcell_1_4_9 Rcell_1_4_10 Rcell_1_4_11 Rcell_1_4_12 Rcell_1_4_13 Rcell_1_4_14 Rcell_1_4_15 Rcell_1_5_0 Rcell_1_5_1 Rcell_1_5_2 Rcell_1_5_3 Rcell_1_5_4 Rcell_1_5_5 Rcell_1_5_6 Rcell_1_5_7 Rcell_1_5_8 Rcell_1_5_9 Rcell_1_5_10 Rcell_1_5_11 Rcell_1_5_12 Rcell_1_5_13 Rcell_1_5_14 Rcell_1_5_15 Rcell_1_6_0 Rcell_1_6_1 Rcell_1_6_2 Rcell_1_6_3 Rcell_1_6_4 Rcell_1_6_5 Rcell_1_6_6 Rcell_1_6_7 Rcell_1_6_8 Rcell_1_6_9 Rcell_1_6_10 Rcell_1_6_11 Rcell_1_6_12 Rcell_1_6_13 Rcell_1_6_14 Rcell_1_6_15 Rcell_1_7_0 Rcell_1_7_1 Rcell_1_7_2 Rcell_1_7_3 Rcell_1_7_4 Rcell_1_7_5 Rcell_1_7_6 Rcell_1_7_7 Rcell_1_7_8 Rcell_1_7_9 Rcell_1_7_10 Rcell_1_7_11 Rcell_1_7_12 Rcell_1_7_13 Rcell_1_7_14 Rcell_1_7_15 Rcell_1_8_0 Rcell_1_8_1 Rcell_1_8_2 Rcell_1_8_3 Rcell_1_8_4 Rcell_1_8_5 Rcell_1_8_6 Rcell_1_8_7 Rcell_1_8_8 Rcell_1_8_9 Rcell_1_8_10 Rcell_1_8_11 Rcell_1_8_12 Rcell_1_8_13 Rcell_1_8_14 Rcell_1_8_15 Rcell_1_9_0 Rcell_1_9_1 Rcell_1_9_2 Rcell_1_9_3 Rcell_1_9_4 Rcell_1_9_5 Rcell_1_9_6 Rcell_1_9_7 Rcell_1_9_8 Rcell_1_9_9 Rcell_1_9_10 Rcell_1_9_11 Rcell_1_9_12 Rcell_1_9_13 Rcell_1_9_14 Rcell_1_9_15 Rcell_1_10_0 Rcell_1_10_1 Rcell_1_10_2 Rcell_1_10_3 Rcell_1_10_4 Rcell_1_10_5 Rcell_1_10_6 Rcell_1_10_7 Rcell_1_10_8 Rcell_1_10_9 Rcell_1_10_10 Rcell_1_10_11 Rcell_1_10_12 Rcell_1_10_13 Rcell_1_10_14 Rcell_1_10_15 Rcell_1_11_0 Rcell_1_11_1 Rcell_1_11_2 Rcell_1_11_3 Rcell_1_11_4 Rcell_1_11_5 Rcell_1_11_6 Rcell_1_11_7 Rcell_1_11_8 Rcell_1_11_9 Rcell_1_11_10 Rcell_1_11_11 Rcell_1_11_12 Rcell_1_11_13 Rcell_1_11_14 Rcell_1_11_15 Rcell_1_12_0 Rcell_1_12_1 Rcell_1_12_2 Rcell_1_12_3 Rcell_1_12_4 Rcell_1_12_5 Rcell_1_12_6 Rcell_1_12_7 Rcell_1_12_8 Rcell_1_12_9 Rcell_1_12_10 Rcell_1_12_11 Rcell_1_12_12 Rcell_1_12_13 Rcell_1_12_14 Rcell_1_12_15 Rcell_1_13_0 Rcell_1_13_1 Rcell_1_13_2 Rcell_1_13_3 Rcell_1_13_4 Rcell_1_13_5 Rcell_1_13_6 Rcell_1_13_7 Rcell_1_13_8 Rcell_1_13_9 Rcell_1_13_10 Rcell_1_13_11 Rcell_1_13_12 Rcell_1_13_13 Rcell_1_13_14 Rcell_1_13_15 Rcell_1_14_0 Rcell_1_14_1 Rcell_1_14_2 Rcell_1_14_3 Rcell_1_14_4 Rcell_1_14_5 Rcell_1_14_6 Rcell_1_14_7 Rcell_1_14_8 Rcell_1_14_9 Rcell_1_14_10 Rcell_1_14_11 Rcell_1_14_12 Rcell_1_14_13 Rcell_1_14_14 Rcell_1_14_15 Rcell_1_15_0 Rcell_1_15_1 Rcell_1_15_2 Rcell_1_15_3 Rcell_1_15_4 Rcell_1_15_5 Rcell_1_15_6 Rcell_1_15_7 Rcell_1_15_8 Rcell_1_15_9 Rcell_1_15_10 Rcell_1_15_11 Rcell_1_15_12 Rcell_1_15_13 Rcell_1_15_14 Rcell_1_15_15

xNOT0 (SA_SH SA_SHbar vdd_0 vss PBulkLine NBulkLine) inverter // mux driver
xNOT1 (SA_SHbar SA_SHbuf vdd_0 vss PBulkLine NBulkLine) inverter

xDelay (GBenable Delay vdd_0 vss PBulkLine NBulkLine) delayfive

xNand_ref_0 (LBenbar_0 GBenable tempnand_0 vdd_0 vss PBulkLine NBulkLine) twonand
xNot_ref_0 (tempnand_0 Refenable_0 vdd_0 vss PBulkLine NBulkLine) inverter
xbuffer_INVNOR_ref_0 (vdd_3 vss NBulkLine PBulkLine Refenable_0 Refenable_0_b) buffer_INVNOR_sixteen
xNand_ref_1 (LBenbar_1 GBenable tempnand_1 vdd_0 vss PBulkLine NBulkLine) twonand
xNot_ref_1 (tempnand_1 Refenable_1 vdd_0 vss PBulkLine NBulkLine) inverter
xbuffer_INVNOR_ref_1 (vdd_3 vss NBulkLine PBulkLine Refenable_1 Refenable_1_b) buffer_INVNOR_sixteen

xLB0 (vdd_0 vdd_2 vss NBulkLine PBulkLine LWLencoded_0_0 LWLencoded_0_1 LWLencoded_0_2 LWLencoded_0_3 LBLencoded_0_0 LBLencoded_0_1 LBLencoded_0_2 LBLencoded_0_3 SelLB_0 BLout_0 Delay Refenable_0_b) localblock Rcell_0_0 = Rcell_0_0_0 Rcell_0_1 = Rcell_0_0_1 Rcell_0_2 = Rcell_0_0_2 Rcell_0_3 = Rcell_0_0_3 Rcell_0_4 = Rcell_0_0_4 Rcell_0_5 = Rcell_0_0_5 Rcell_0_6 = Rcell_0_0_6 Rcell_0_7 = Rcell_0_0_7 Rcell_0_8 = Rcell_0_0_8 Rcell_0_9 = Rcell_0_0_9 Rcell_0_10 = Rcell_0_0_10 Rcell_0_11 = Rcell_0_0_11 Rcell_0_12 = Rcell_0_0_12 Rcell_0_13 = Rcell_0_0_13 Rcell_0_14 = Rcell_0_0_14 Rcell_0_15 = Rcell_0_0_15 Rcell_1_0 = Rcell_0_1_0 Rcell_1_1 = Rcell_0_1_1 Rcell_1_2 = Rcell_0_1_2 Rcell_1_3 = Rcell_0_1_3 Rcell_1_4 = Rcell_0_1_4 Rcell_1_5 = Rcell_0_1_5 Rcell_1_6 = Rcell_0_1_6 Rcell_1_7 = Rcell_0_1_7 Rcell_1_8 = Rcell_0_1_8 Rcell_1_9 = Rcell_0_1_9 Rcell_1_10 = Rcell_0_1_10 Rcell_1_11 = Rcell_0_1_11 Rcell_1_12 = Rcell_0_1_12 Rcell_1_13 = Rcell_0_1_13 Rcell_1_14 = Rcell_0_1_14 Rcell_1_15 = Rcell_0_1_15 Rcell_2_0 = Rcell_0_2_0 Rcell_2_1 = Rcell_0_2_1 Rcell_2_2 = Rcell_0_2_2 Rcell_2_3 = Rcell_0_2_3 Rcell_2_4 = Rcell_0_2_4 Rcell_2_5 = Rcell_0_2_5 Rcell_2_6 = Rcell_0_2_6 Rcell_2_7 = Rcell_0_2_7 Rcell_2_8 = Rcell_0_2_8 Rcell_2_9 = Rcell_0_2_9 Rcell_2_10 = Rcell_0_2_10 Rcell_2_11 = Rcell_0_2_11 Rcell_2_12 = Rcell_0_2_12 Rcell_2_13 = Rcell_0_2_13 Rcell_2_14 = Rcell_0_2_14 Rcell_2_15 = Rcell_0_2_15 Rcell_3_0 = Rcell_0_3_0 Rcell_3_1 = Rcell_0_3_1 Rcell_3_2 = Rcell_0_3_2 Rcell_3_3 = Rcell_0_3_3 Rcell_3_4 = Rcell_0_3_4 Rcell_3_5 = Rcell_0_3_5 Rcell_3_6 = Rcell_0_3_6 Rcell_3_7 = Rcell_0_3_7 Rcell_3_8 = Rcell_0_3_8 Rcell_3_9 = Rcell_0_3_9 Rcell_3_10 = Rcell_0_3_10 Rcell_3_11 = Rcell_0_3_11 Rcell_3_12 = Rcell_0_3_12 Rcell_3_13 = Rcell_0_3_13 Rcell_3_14 = Rcell_0_3_14 Rcell_3_15 = Rcell_0_3_15 Rcell_4_0 = Rcell_0_4_0 Rcell_4_1 = Rcell_0_4_1 Rcell_4_2 = Rcell_0_4_2 Rcell_4_3 = Rcell_0_4_3 Rcell_4_4 = Rcell_0_4_4 Rcell_4_5 = Rcell_0_4_5 Rcell_4_6 = Rcell_0_4_6 Rcell_4_7 = Rcell_0_4_7 Rcell_4_8 = Rcell_0_4_8 Rcell_4_9 = Rcell_0_4_9 Rcell_4_10 = Rcell_0_4_10 Rcell_4_11 = Rcell_0_4_11 Rcell_4_12 = Rcell_0_4_12 Rcell_4_13 = Rcell_0_4_13 Rcell_4_14 = Rcell_0_4_14 Rcell_4_15 = Rcell_0_4_15 Rcell_5_0 = Rcell_0_5_0 Rcell_5_1 = Rcell_0_5_1 Rcell_5_2 = Rcell_0_5_2 Rcell_5_3 = Rcell_0_5_3 Rcell_5_4 = Rcell_0_5_4 Rcell_5_5 = Rcell_0_5_5 Rcell_5_6 = Rcell_0_5_6 Rcell_5_7 = Rcell_0_5_7 Rcell_5_8 = Rcell_0_5_8 Rcell_5_9 = Rcell_0_5_9 Rcell_5_10 = Rcell_0_5_10 Rcell_5_11 = Rcell_0_5_11 Rcell_5_12 = Rcell_0_5_12 Rcell_5_13 = Rcell_0_5_13 Rcell_5_14 = Rcell_0_5_14 Rcell_5_15 = Rcell_0_5_15 Rcell_6_0 = Rcell_0_6_0 Rcell_6_1 = Rcell_0_6_1 Rcell_6_2 = Rcell_0_6_2 Rcell_6_3 = Rcell_0_6_3 Rcell_6_4 = Rcell_0_6_4 Rcell_6_5 = Rcell_0_6_5 Rcell_6_6 = Rcell_0_6_6 Rcell_6_7 = Rcell_0_6_7 Rcell_6_8 = Rcell_0_6_8 Rcell_6_9 = Rcell_0_6_9 Rcell_6_10 = Rcell_0_6_10 Rcell_6_11 = Rcell_0_6_11 Rcell_6_12 = Rcell_0_6_12 Rcell_6_13 = Rcell_0_6_13 Rcell_6_14 = Rcell_0_6_14 Rcell_6_15 = Rcell_0_6_15 Rcell_7_0 = Rcell_0_7_0 Rcell_7_1 = Rcell_0_7_1 Rcell_7_2 = Rcell_0_7_2 Rcell_7_3 = Rcell_0_7_3 Rcell_7_4 = Rcell_0_7_4 Rcell_7_5 = Rcell_0_7_5 Rcell_7_6 = Rcell_0_7_6 Rcell_7_7 = Rcell_0_7_7 Rcell_7_8 = Rcell_0_7_8 Rcell_7_9 = Rcell_0_7_9 Rcell_7_10 = Rcell_0_7_10 Rcell_7_11 = Rcell_0_7_11 Rcell_7_12 = Rcell_0_7_12 Rcell_7_13 = Rcell_0_7_13 Rcell_7_14 = Rcell_0_7_14 Rcell_7_15 = Rcell_0_7_15 Rcell_8_0 = Rcell_0_8_0 Rcell_8_1 = Rcell_0_8_1 Rcell_8_2 = Rcell_0_8_2 Rcell_8_3 = Rcell_0_8_3 Rcell_8_4 = Rcell_0_8_4 Rcell_8_5 = Rcell_0_8_5 Rcell_8_6 = Rcell_0_8_6 Rcell_8_7 = Rcell_0_8_7 Rcell_8_8 = Rcell_0_8_8 Rcell_8_9 = Rcell_0_8_9 Rcell_8_10 = Rcell_0_8_10 Rcell_8_11 = Rcell_0_8_11 Rcell_8_12 = Rcell_0_8_12 Rcell_8_13 = Rcell_0_8_13 Rcell_8_14 = Rcell_0_8_14 Rcell_8_15 = Rcell_0_8_15 Rcell_9_0 = Rcell_0_9_0 Rcell_9_1 = Rcell_0_9_1 Rcell_9_2 = Rcell_0_9_2 Rcell_9_3 = Rcell_0_9_3 Rcell_9_4 = Rcell_0_9_4 Rcell_9_5 = Rcell_0_9_5 Rcell_9_6 = Rcell_0_9_6 Rcell_9_7 = Rcell_0_9_7 Rcell_9_8 = Rcell_0_9_8 Rcell_9_9 = Rcell_0_9_9 Rcell_9_10 = Rcell_0_9_10 Rcell_9_11 = Rcell_0_9_11 Rcell_9_12 = Rcell_0_9_12 Rcell_9_13 = Rcell_0_9_13 Rcell_9_14 = Rcell_0_9_14 Rcell_9_15 = Rcell_0_9_15 Rcell_10_0 = Rcell_0_10_0 Rcell_10_1 = Rcell_0_10_1 Rcell_10_2 = Rcell_0_10_2 Rcell_10_3 = Rcell_0_10_3 Rcell_10_4 = Rcell_0_10_4 Rcell_10_5 = Rcell_0_10_5 Rcell_10_6 = Rcell_0_10_6 Rcell_10_7 = Rcell_0_10_7 Rcell_10_8 = Rcell_0_10_8 Rcell_10_9 = Rcell_0_10_9 Rcell_10_10 = Rcell_0_10_10 Rcell_10_11 = Rcell_0_10_11 Rcell_10_12 = Rcell_0_10_12 Rcell_10_13 = Rcell_0_10_13 Rcell_10_14 = Rcell_0_10_14 Rcell_10_15 = Rcell_0_10_15 Rcell_11_0 = Rcell_0_11_0 Rcell_11_1 = Rcell_0_11_1 Rcell_11_2 = Rcell_0_11_2 Rcell_11_3 = Rcell_0_11_3 Rcell_11_4 = Rcell_0_11_4 Rcell_11_5 = Rcell_0_11_5 Rcell_11_6 = Rcell_0_11_6 Rcell_11_7 = Rcell_0_11_7 Rcell_11_8 = Rcell_0_11_8 Rcell_11_9 = Rcell_0_11_9 Rcell_11_10 = Rcell_0_11_10 Rcell_11_11 = Rcell_0_11_11 Rcell_11_12 = Rcell_0_11_12 Rcell_11_13 = Rcell_0_11_13 Rcell_11_14 = Rcell_0_11_14 Rcell_11_15 = Rcell_0_11_15 Rcell_12_0 = Rcell_0_12_0 Rcell_12_1 = Rcell_0_12_1 Rcell_12_2 = Rcell_0_12_2 Rcell_12_3 = Rcell_0_12_3 Rcell_12_4 = Rcell_0_12_4 Rcell_12_5 = Rcell_0_12_5 Rcell_12_6 = Rcell_0_12_6 Rcell_12_7 = Rcell_0_12_7 Rcell_12_8 = Rcell_0_12_8 Rcell_12_9 = Rcell_0_12_9 Rcell_12_10 = Rcell_0_12_10 Rcell_12_11 = Rcell_0_12_11 Rcell_12_12 = Rcell_0_12_12 Rcell_12_13 = Rcell_0_12_13 Rcell_12_14 = Rcell_0_12_14 Rcell_12_15 = Rcell_0_12_15 Rcell_13_0 = Rcell_0_13_0 Rcell_13_1 = Rcell_0_13_1 Rcell_13_2 = Rcell_0_13_2 Rcell_13_3 = Rcell_0_13_3 Rcell_13_4 = Rcell_0_13_4 Rcell_13_5 = Rcell_0_13_5 Rcell_13_6 = Rcell_0_13_6 Rcell_13_7 = Rcell_0_13_7 Rcell_13_8 = Rcell_0_13_8 Rcell_13_9 = Rcell_0_13_9 Rcell_13_10 = Rcell_0_13_10 Rcell_13_11 = Rcell_0_13_11 Rcell_13_12 = Rcell_0_13_12 Rcell_13_13 = Rcell_0_13_13 Rcell_13_14 = Rcell_0_13_14 Rcell_13_15 = Rcell_0_13_15 Rcell_14_0 = Rcell_0_14_0 Rcell_14_1 = Rcell_0_14_1 Rcell_14_2 = Rcell_0_14_2 Rcell_14_3 = Rcell_0_14_3 Rcell_14_4 = Rcell_0_14_4 Rcell_14_5 = Rcell_0_14_5 Rcell_14_6 = Rcell_0_14_6 Rcell_14_7 = Rcell_0_14_7 Rcell_14_8 = Rcell_0_14_8 Rcell_14_9 = Rcell_0_14_9 Rcell_14_10 = Rcell_0_14_10 Rcell_14_11 = Rcell_0_14_11 Rcell_14_12 = Rcell_0_14_12 Rcell_14_13 = Rcell_0_14_13 Rcell_14_14 = Rcell_0_14_14 Rcell_14_15 = Rcell_0_14_15 Rcell_15_0 = Rcell_0_15_0 Rcell_15_1 = Rcell_0_15_1 Rcell_15_2 = Rcell_0_15_2 Rcell_15_3 = Rcell_0_15_3 Rcell_15_4 = Rcell_0_15_4 Rcell_15_5 = Rcell_0_15_5 Rcell_15_6 = Rcell_0_15_6 Rcell_15_7 = Rcell_0_15_7 Rcell_15_8 = Rcell_0_15_8 Rcell_15_9 = Rcell_0_15_9 Rcell_15_10 = Rcell_0_15_10 Rcell_15_11 = Rcell_0_15_11 Rcell_15_12 = Rcell_0_15_12 Rcell_15_13 = Rcell_0_15_13 Rcell_15_14 = Rcell_0_15_14 Rcell_15_15 = Rcell_0_15_15
xM0n BLout_0 SA_SHbuf InOut NBulkLine mosn_h w=PWmuxGB l=PLmin //mux
xM0p BLout_0 SA_SHbar InOut PBulkLine mosp_h w=PWmuxGB l=PLmin

xLB1 (vdd_0 vdd_2 vss NBulkLine PBulkLine LWLencoded_1_0 LWLencoded_1_1 LWLencoded_1_2 LWLencoded_1_3 LBLencoded_1_0 LBLencoded_1_1 LBLencoded_1_2 LBLencoded_1_3 SelLB_1 BLout_1 Delay Refenable_1_b) localblock Rcell_0_0 = Rcell_1_0_0 Rcell_0_1 = Rcell_1_0_1 Rcell_0_2 = Rcell_1_0_2 Rcell_0_3 = Rcell_1_0_3 Rcell_0_4 = Rcell_1_0_4 Rcell_0_5 = Rcell_1_0_5 Rcell_0_6 = Rcell_1_0_6 Rcell_0_7 = Rcell_1_0_7 Rcell_0_8 = Rcell_1_0_8 Rcell_0_9 = Rcell_1_0_9 Rcell_0_10 = Rcell_1_0_10 Rcell_0_11 = Rcell_1_0_11 Rcell_0_12 = Rcell_1_0_12 Rcell_0_13 = Rcell_1_0_13 Rcell_0_14 = Rcell_1_0_14 Rcell_0_15 = Rcell_1_0_15 Rcell_1_0 = Rcell_1_1_0 Rcell_1_1 = Rcell_1_1_1 Rcell_1_2 = Rcell_1_1_2 Rcell_1_3 = Rcell_1_1_3 Rcell_1_4 = Rcell_1_1_4 Rcell_1_5 = Rcell_1_1_5 Rcell_1_6 = Rcell_1_1_6 Rcell_1_7 = Rcell_1_1_7 Rcell_1_8 = Rcell_1_1_8 Rcell_1_9 = Rcell_1_1_9 Rcell_1_10 = Rcell_1_1_10 Rcell_1_11 = Rcell_1_1_11 Rcell_1_12 = Rcell_1_1_12 Rcell_1_13 = Rcell_1_1_13 Rcell_1_14 = Rcell_1_1_14 Rcell_1_15 = Rcell_1_1_15 Rcell_2_0 = Rcell_1_2_0 Rcell_2_1 = Rcell_1_2_1 Rcell_2_2 = Rcell_1_2_2 Rcell_2_3 = Rcell_1_2_3 Rcell_2_4 = Rcell_1_2_4 Rcell_2_5 = Rcell_1_2_5 Rcell_2_6 = Rcell_1_2_6 Rcell_2_7 = Rcell_1_2_7 Rcell_2_8 = Rcell_1_2_8 Rcell_2_9 = Rcell_1_2_9 Rcell_2_10 = Rcell_1_2_10 Rcell_2_11 = Rcell_1_2_11 Rcell_2_12 = Rcell_1_2_12 Rcell_2_13 = Rcell_1_2_13 Rcell_2_14 = Rcell_1_2_14 Rcell_2_15 = Rcell_1_2_15 Rcell_3_0 = Rcell_1_3_0 Rcell_3_1 = Rcell_1_3_1 Rcell_3_2 = Rcell_1_3_2 Rcell_3_3 = Rcell_1_3_3 Rcell_3_4 = Rcell_1_3_4 Rcell_3_5 = Rcell_1_3_5 Rcell_3_6 = Rcell_1_3_6 Rcell_3_7 = Rcell_1_3_7 Rcell_3_8 = Rcell_1_3_8 Rcell_3_9 = Rcell_1_3_9 Rcell_3_10 = Rcell_1_3_10 Rcell_3_11 = Rcell_1_3_11 Rcell_3_12 = Rcell_1_3_12 Rcell_3_13 = Rcell_1_3_13 Rcell_3_14 = Rcell_1_3_14 Rcell_3_15 = Rcell_1_3_15 Rcell_4_0 = Rcell_1_4_0 Rcell_4_1 = Rcell_1_4_1 Rcell_4_2 = Rcell_1_4_2 Rcell_4_3 = Rcell_1_4_3 Rcell_4_4 = Rcell_1_4_4 Rcell_4_5 = Rcell_1_4_5 Rcell_4_6 = Rcell_1_4_6 Rcell_4_7 = Rcell_1_4_7 Rcell_4_8 = Rcell_1_4_8 Rcell_4_9 = Rcell_1_4_9 Rcell_4_10 = Rcell_1_4_10 Rcell_4_11 = Rcell_1_4_11 Rcell_4_12 = Rcell_1_4_12 Rcell_4_13 = Rcell_1_4_13 Rcell_4_14 = Rcell_1_4_14 Rcell_4_15 = Rcell_1_4_15 Rcell_5_0 = Rcell_1_5_0 Rcell_5_1 = Rcell_1_5_1 Rcell_5_2 = Rcell_1_5_2 Rcell_5_3 = Rcell_1_5_3 Rcell_5_4 = Rcell_1_5_4 Rcell_5_5 = Rcell_1_5_5 Rcell_5_6 = Rcell_1_5_6 Rcell_5_7 = Rcell_1_5_7 Rcell_5_8 = Rcell_1_5_8 Rcell_5_9 = Rcell_1_5_9 Rcell_5_10 = Rcell_1_5_10 Rcell_5_11 = Rcell_1_5_11 Rcell_5_12 = Rcell_1_5_12 Rcell_5_13 = Rcell_1_5_13 Rcell_5_14 = Rcell_1_5_14 Rcell_5_15 = Rcell_1_5_15 Rcell_6_0 = Rcell_1_6_0 Rcell_6_1 = Rcell_1_6_1 Rcell_6_2 = Rcell_1_6_2 Rcell_6_3 = Rcell_1_6_3 Rcell_6_4 = Rcell_1_6_4 Rcell_6_5 = Rcell_1_6_5 Rcell_6_6 = Rcell_1_6_6 Rcell_6_7 = Rcell_1_6_7 Rcell_6_8 = Rcell_1_6_8 Rcell_6_9 = Rcell_1_6_9 Rcell_6_10 = Rcell_1_6_10 Rcell_6_11 = Rcell_1_6_11 Rcell_6_12 = Rcell_1_6_12 Rcell_6_13 = Rcell_1_6_13 Rcell_6_14 = Rcell_1_6_14 Rcell_6_15 = Rcell_1_6_15 Rcell_7_0 = Rcell_1_7_0 Rcell_7_1 = Rcell_1_7_1 Rcell_7_2 = Rcell_1_7_2 Rcell_7_3 = Rcell_1_7_3 Rcell_7_4 = Rcell_1_7_4 Rcell_7_5 = Rcell_1_7_5 Rcell_7_6 = Rcell_1_7_6 Rcell_7_7 = Rcell_1_7_7 Rcell_7_8 = Rcell_1_7_8 Rcell_7_9 = Rcell_1_7_9 Rcell_7_10 = Rcell_1_7_10 Rcell_7_11 = Rcell_1_7_11 Rcell_7_12 = Rcell_1_7_12 Rcell_7_13 = Rcell_1_7_13 Rcell_7_14 = Rcell_1_7_14 Rcell_7_15 = Rcell_1_7_15 Rcell_8_0 = Rcell_1_8_0 Rcell_8_1 = Rcell_1_8_1 Rcell_8_2 = Rcell_1_8_2 Rcell_8_3 = Rcell_1_8_3 Rcell_8_4 = Rcell_1_8_4 Rcell_8_5 = Rcell_1_8_5 Rcell_8_6 = Rcell_1_8_6 Rcell_8_7 = Rcell_1_8_7 Rcell_8_8 = Rcell_1_8_8 Rcell_8_9 = Rcell_1_8_9 Rcell_8_10 = Rcell_1_8_10 Rcell_8_11 = Rcell_1_8_11 Rcell_8_12 = Rcell_1_8_12 Rcell_8_13 = Rcell_1_8_13 Rcell_8_14 = Rcell_1_8_14 Rcell_8_15 = Rcell_1_8_15 Rcell_9_0 = Rcell_1_9_0 Rcell_9_1 = Rcell_1_9_1 Rcell_9_2 = Rcell_1_9_2 Rcell_9_3 = Rcell_1_9_3 Rcell_9_4 = Rcell_1_9_4 Rcell_9_5 = Rcell_1_9_5 Rcell_9_6 = Rcell_1_9_6 Rcell_9_7 = Rcell_1_9_7 Rcell_9_8 = Rcell_1_9_8 Rcell_9_9 = Rcell_1_9_9 Rcell_9_10 = Rcell_1_9_10 Rcell_9_11 = Rcell_1_9_11 Rcell_9_12 = Rcell_1_9_12 Rcell_9_13 = Rcell_1_9_13 Rcell_9_14 = Rcell_1_9_14 Rcell_9_15 = Rcell_1_9_15 Rcell_10_0 = Rcell_1_10_0 Rcell_10_1 = Rcell_1_10_1 Rcell_10_2 = Rcell_1_10_2 Rcell_10_3 = Rcell_1_10_3 Rcell_10_4 = Rcell_1_10_4 Rcell_10_5 = Rcell_1_10_5 Rcell_10_6 = Rcell_1_10_6 Rcell_10_7 = Rcell_1_10_7 Rcell_10_8 = Rcell_1_10_8 Rcell_10_9 = Rcell_1_10_9 Rcell_10_10 = Rcell_1_10_10 Rcell_10_11 = Rcell_1_10_11 Rcell_10_12 = Rcell_1_10_12 Rcell_10_13 = Rcell_1_10_13 Rcell_10_14 = Rcell_1_10_14 Rcell_10_15 = Rcell_1_10_15 Rcell_11_0 = Rcell_1_11_0 Rcell_11_1 = Rcell_1_11_1 Rcell_11_2 = Rcell_1_11_2 Rcell_11_3 = Rcell_1_11_3 Rcell_11_4 = Rcell_1_11_4 Rcell_11_5 = Rcell_1_11_5 Rcell_11_6 = Rcell_1_11_6 Rcell_11_7 = Rcell_1_11_7 Rcell_11_8 = Rcell_1_11_8 Rcell_11_9 = Rcell_1_11_9 Rcell_11_10 = Rcell_1_11_10 Rcell_11_11 = Rcell_1_11_11 Rcell_11_12 = Rcell_1_11_12 Rcell_11_13 = Rcell_1_11_13 Rcell_11_14 = Rcell_1_11_14 Rcell_11_15 = Rcell_1_11_15 Rcell_12_0 = Rcell_1_12_0 Rcell_12_1 = Rcell_1_12_1 Rcell_12_2 = Rcell_1_12_2 Rcell_12_3 = Rcell_1_12_3 Rcell_12_4 = Rcell_1_12_4 Rcell_12_5 = Rcell_1_12_5 Rcell_12_6 = Rcell_1_12_6 Rcell_12_7 = Rcell_1_12_7 Rcell_12_8 = Rcell_1_12_8 Rcell_12_9 = Rcell_1_12_9 Rcell_12_10 = Rcell_1_12_10 Rcell_12_11 = Rcell_1_12_11 Rcell_12_12 = Rcell_1_12_12 Rcell_12_13 = Rcell_1_12_13 Rcell_12_14 = Rcell_1_12_14 Rcell_12_15 = Rcell_1_12_15 Rcell_13_0 = Rcell_1_13_0 Rcell_13_1 = Rcell_1_13_1 Rcell_13_2 = Rcell_1_13_2 Rcell_13_3 = Rcell_1_13_3 Rcell_13_4 = Rcell_1_13_4 Rcell_13_5 = Rcell_1_13_5 Rcell_13_6 = Rcell_1_13_6 Rcell_13_7 = Rcell_1_13_7 Rcell_13_8 = Rcell_1_13_8 Rcell_13_9 = Rcell_1_13_9 Rcell_13_10 = Rcell_1_13_10 Rcell_13_11 = Rcell_1_13_11 Rcell_13_12 = Rcell_1_13_12 Rcell_13_13 = Rcell_1_13_13 Rcell_13_14 = Rcell_1_13_14 Rcell_13_15 = Rcell_1_13_15 Rcell_14_0 = Rcell_1_14_0 Rcell_14_1 = Rcell_1_14_1 Rcell_14_2 = Rcell_1_14_2 Rcell_14_3 = Rcell_1_14_3 Rcell_14_4 = Rcell_1_14_4 Rcell_14_5 = Rcell_1_14_5 Rcell_14_6 = Rcell_1_14_6 Rcell_14_7 = Rcell_1_14_7 Rcell_14_8 = Rcell_1_14_8 Rcell_14_9 = Rcell_1_14_9 Rcell_14_10 = Rcell_1_14_10 Rcell_14_11 = Rcell_1_14_11 Rcell_14_12 = Rcell_1_14_12 Rcell_14_13 = Rcell_1_14_13 Rcell_14_14 = Rcell_1_14_14 Rcell_14_15 = Rcell_1_14_15 Rcell_15_0 = Rcell_1_15_0 Rcell_15_1 = Rcell_1_15_1 Rcell_15_2 = Rcell_1_15_2 Rcell_15_3 = Rcell_1_15_3 Rcell_15_4 = Rcell_1_15_4 Rcell_15_5 = Rcell_1_15_5 Rcell_15_6 = Rcell_1_15_6 Rcell_15_7 = Rcell_1_15_7 Rcell_15_8 = Rcell_1_15_8 Rcell_15_9 = Rcell_1_15_9 Rcell_15_10 = Rcell_1_15_10 Rcell_15_11 = Rcell_1_15_11 Rcell_15_12 = Rcell_1_15_12 Rcell_15_13 = Rcell_1_15_13 Rcell_15_14 = Rcell_1_15_14 Rcell_15_15 = Rcell_1_15_15
xM1n BLout_1 SA_SHbuf InOutbar NBulkLine mc_nmos_hvt w=PWmuxGB l=PLmin
xM1p BLout_1 SA_SHbar InOutbar PBulkLine mc_pmos_hvt w=PWmuxGB l=PLmin

xSA (vdd_1 vss NBulkLine PBulkLine InOut InOutbar EnableSAP EnableSAN) senseamplifier

ends globalblock
